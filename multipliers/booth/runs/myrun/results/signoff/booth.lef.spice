* NGSPICE file created from booth.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_4 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_4 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_1 abstract view
.subckt sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd1_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd1_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_1 abstract view
.subckt sky130_fd_sc_hd__o211ai_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_2 abstract view
.subckt sky130_fd_sc_hd__xnor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_6 abstract view
.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_1 abstract view
.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_2 abstract view
.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_1 abstract view
.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_2 abstract view
.subckt sky130_fd_sc_hd__o21a_2 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_1 abstract view
.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_4 abstract view
.subckt sky130_fd_sc_hd__mux2_4 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_2 abstract view
.subckt sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_4 abstract view
.subckt sky130_fd_sc_hd__and2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_8 abstract view
.subckt sky130_fd_sc_hd__buf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_4 abstract view
.subckt sky130_fd_sc_hd__xor2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_2 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_2 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_4 abstract view
.subckt sky130_fd_sc_hd__or4_4 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_2 abstract view
.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_1 abstract view
.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_2 abstract view
.subckt sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_2 abstract view
.subckt sky130_fd_sc_hd__a32o_2 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_4 abstract view
.subckt sky130_fd_sc_hd__nand2b_4 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_1 abstract view
.subckt sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_2 abstract view
.subckt sky130_fd_sc_hd__o21bai_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_2 abstract view
.subckt sky130_fd_sc_hd__o211ai_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_4 abstract view
.subckt sky130_fd_sc_hd__o22ai_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_1 abstract view
.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_4 abstract view
.subckt sky130_fd_sc_hd__xnor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_12 abstract view
.subckt sky130_fd_sc_hd__buf_12 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_2 abstract view
.subckt sky130_fd_sc_hd__a21boi_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221a_1 abstract view
.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_2 abstract view
.subckt sky130_fd_sc_hd__o22a_2 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_2 abstract view
.subckt sky130_fd_sc_hd__mux2_2 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_2 abstract view
.subckt sky130_fd_sc_hd__or2b_2 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_2 abstract view
.subckt sky130_fd_sc_hd__a211oi_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2b_2 abstract view
.subckt sky130_fd_sc_hd__nor2b_2 A B_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_4 abstract view
.subckt sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_4 abstract view
.subckt sky130_fd_sc_hd__and3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41o_1 abstract view
.subckt sky130_fd_sc_hd__a41o_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_1 abstract view
.subckt sky130_fd_sc_hd__a22oi_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_4 abstract view
.subckt sky130_fd_sc_hd__or2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_4 abstract view
.subckt sky130_fd_sc_hd__or3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_4 abstract view
.subckt sky130_fd_sc_hd__o21ai_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_1 abstract view
.subckt sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

.subckt booth VGND VPWR multiplicand[0] multiplicand[1] multiplicand[2] multiplicand[3]
+ multiplicand[4] multiplicand[5] multiplicand[6] multiplicand[7] multiplier[0] multiplier[1]
+ multiplier[2] multiplier[3] multiplier[4] multiplier[5] multiplier[6] multiplier[7]
+ product[0] product[10] product[11] product[12] product[13] product[14] product[15]
+ product[1] product[2] product[3] product[4] product[5] product[6] product[7] product[8]
+ product[9]
XTAP_177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_501_ net10 _410_ _432_ _433_ VGND VGND VPWR VPWR _434_ sky130_fd_sc_hd__o2bb2a_4
XFILLER_0_23_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer7 _174_ VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_95 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_895_ _380_ VGND VGND VPWR VPWR _381_ sky130_fd_sc_hd__inv_2
XFILLER_0_0_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_103 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_680_ _430_ _014_ _153_ _154_ VGND VGND VPWR VPWR _158_ sky130_fd_sc_hd__a31o_1
X_878_ _338_ _362_ _339_ VGND VGND VPWR VPWR _363_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_21_40 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xsplit8 _418_ VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__clkbuf_2
X_801_ _279_ _280_ VGND VGND VPWR VPWR _282_ sky130_fd_sc_hd__nor2_1
X_732_ _070_ _203_ VGND VGND VPWR VPWR _209_ sky130_fd_sc_hd__and2_1
XFILLER_0_26_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_594_ _072_ VGND VGND VPWR VPWR _073_ sky130_fd_sc_hd__clkbuf_4
X_663_ net16 net15 VGND VGND VPWR VPWR _142_ sky130_fd_sc_hd__or2b_1
XFILLER_0_38_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer17 net48 VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_16_62 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput31 net31 VGND VGND VPWR VPWR product[8] sky130_fd_sc_hd__clkbuf_4
Xoutput20 net20 VGND VGND VPWR VPWR product[12] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_37_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_715_ _131_ _139_ VGND VGND VPWR VPWR _193_ sky130_fd_sc_hd__nand2_1
X_577_ _043_ _052_ _055_ VGND VGND VPWR VPWR _056_ sky130_fd_sc_hd__a21bo_1
X_646_ _123_ _124_ _248_ VGND VGND VPWR VPWR _125_ sky130_fd_sc_hd__mux2_1
XFILLER_0_41_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_500_ _413_ _415_ _366_ VGND VGND VPWR VPWR _433_ sky130_fd_sc_hd__o21ai_1
Xrebuffer8 _442_ VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_23_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_629_ _083_ _095_ VGND VGND VPWR VPWR _108_ sky130_fd_sc_hd__nor2_1
XFILLER_0_1_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_215 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_894_ _015_ _259_ _369_ _379_ VGND VGND VPWR VPWR _380_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_0_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_877_ _333_ _361_ VGND VGND VPWR VPWR _362_ sky130_fd_sc_hd__and2b_1
XFILLER_0_16_118 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_662_ _140_ VGND VGND VPWR VPWR _141_ sky130_fd_sc_hd__clkbuf_4
X_800_ net56 _440_ _141_ VGND VGND VPWR VPWR _280_ sky130_fd_sc_hd__mux2_1
X_731_ _205_ _207_ VGND VGND VPWR VPWR _208_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_42_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_593_ net12 net13 VGND VGND VPWR VPWR _072_ sky130_fd_sc_hd__or2b_1
XFILLER_0_6_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer18 _062_ VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__buf_1
Xoutput21 net21 VGND VGND VPWR VPWR product[13] sky130_fd_sc_hd__buf_6
Xoutput32 net32 VGND VGND VPWR VPWR product[9] sky130_fd_sc_hd__clkbuf_4
X_714_ _190_ _191_ VGND VGND VPWR VPWR _192_ sky130_fd_sc_hd__nand2_1
X_645_ _000_ VGND VGND VPWR VPWR _124_ sky130_fd_sc_hd__inv_2
X_576_ _039_ _053_ _054_ _041_ VGND VGND VPWR VPWR _055_ sky130_fd_sc_hd__a211o_1
XFILLER_0_41_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_40 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer9 _017_ VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_23_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_628_ _105_ _106_ VGND VGND VPWR VPWR _107_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_13_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_227 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_559_ _427_ _029_ VGND VGND VPWR VPWR _038_ sky130_fd_sc_hd__nand2_1
XFILLER_0_1_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_893_ _200_ _248_ _016_ VGND VGND VPWR VPWR _379_ sky130_fd_sc_hd__or3b_1
XFILLER_0_3_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_185 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_876_ _200_ _017_ _291_ VGND VGND VPWR VPWR _361_ sky130_fd_sc_hd__mux2_1
XFILLER_0_30_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_661_ net15 net16 VGND VGND VPWR VPWR _140_ sky130_fd_sc_hd__or2b_1
X_730_ _150_ _163_ _206_ VGND VGND VPWR VPWR _207_ sky130_fd_sc_hd__a21oi_2
X_592_ _070_ _033_ VGND VGND VPWR VPWR _071_ sky130_fd_sc_hd__and2_1
XFILLER_0_6_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_859_ _309_ VGND VGND VPWR VPWR _343_ sky130_fd_sc_hd__inv_2
Xrebuffer19 _216_ VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_29_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_105 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput22 net22 VGND VGND VPWR VPWR product[14] sky130_fd_sc_hd__buf_6
X_575_ _031_ _434_ VGND VGND VPWR VPWR _054_ sky130_fd_sc_hd__and2_1
X_713_ _188_ _189_ VGND VGND VPWR VPWR _191_ sky130_fd_sc_hd__nand2_1
X_644_ _438_ VGND VGND VPWR VPWR _123_ sky130_fd_sc_hd__inv_2
XFILLER_0_41_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_558_ _442_ _011_ _031_ VGND VGND VPWR VPWR _037_ sky130_fd_sc_hd__a21oi_1
X_627_ net59 _447_ _291_ VGND VGND VPWR VPWR _106_ sky130_fd_sc_hd__mux2_1
X_489_ _419_ _421_ VGND VGND VPWR VPWR _422_ sky130_fd_sc_hd__and2b_1
XFILLER_0_14_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_892_ _378_ VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_28_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_19 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_172 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_875_ _358_ _344_ _359_ VGND VGND VPWR VPWR _360_ sky130_fd_sc_hd__a21o_1
XFILLER_0_24_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_591_ _069_ VGND VGND VPWR VPWR _070_ sky130_fd_sc_hd__clkbuf_4
X_660_ _270_ _122_ _135_ _138_ VGND VGND VPWR VPWR _139_ sky130_fd_sc_hd__o22a_1
XFILLER_0_21_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_858_ _340_ _341_ VGND VGND VPWR VPWR _342_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_8_117 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_789_ _243_ _267_ VGND VGND VPWR VPWR _268_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_29_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput23 net23 VGND VGND VPWR VPWR product[15] sky130_fd_sc_hd__buf_6
X_712_ _188_ _189_ VGND VGND VPWR VPWR _190_ sky130_fd_sc_hd__or2_1
X_574_ net57 _011_ VGND VGND VPWR VPWR _053_ sky130_fd_sc_hd__xnor2_2
X_643_ _324_ net36 _121_ VGND VGND VPWR VPWR _122_ sky130_fd_sc_hd__o21ai_1
XTAP_126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_557_ _442_ _011_ VGND VGND VPWR VPWR _036_ sky130_fd_sc_hd__or2_1
X_626_ _098_ _101_ _104_ VGND VGND VPWR VPWR _105_ sky130_fd_sc_hd__o21a_2
X_488_ _417_ _411_ _418_ _377_ _420_ VGND VGND VPWR VPWR _421_ sky130_fd_sc_hd__a221o_1
XFILLER_0_22_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_609_ _438_ _000_ _073_ VGND VGND VPWR VPWR _088_ sky130_fd_sc_hd__mux2_1
XFILLER_0_40_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_891_ _370_ _376_ _143_ VGND VGND VPWR VPWR _378_ sky130_fd_sc_hd__mux2_4
XFILLER_0_27_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_132 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_874_ _340_ _341_ VGND VGND VPWR VPWR _359_ sky130_fd_sc_hd__nor2_1
XFILLER_0_1_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_590_ _334_ _345_ VGND VGND VPWR VPWR _069_ sky130_fd_sc_hd__and2_1
XFILLER_0_38_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_857_ net7 net40 _248_ VGND VGND VPWR VPWR _341_ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_788_ _265_ _266_ VGND VGND VPWR VPWR _267_ sky130_fd_sc_hd__xor2_2
XFILLER_0_8_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput24 net24 VGND VGND VPWR VPWR product[1] sky130_fd_sc_hd__clkbuf_4
X_642_ _313_ _105_ VGND VGND VPWR VPWR _121_ sky130_fd_sc_hd__nand2_1
X_711_ _438_ _000_ _141_ VGND VGND VPWR VPWR _189_ sky130_fd_sc_hd__mux2_1
X_573_ _046_ _050_ _051_ VGND VGND VPWR VPWR _052_ sky130_fd_sc_hd__a21o_1
XFILLER_0_26_216 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_909_ _131_ _270_ VGND VGND VPWR VPWR _394_ sky130_fd_sc_hd__nand2_1
XFILLER_0_43_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_625_ _102_ _068_ _071_ _103_ VGND VGND VPWR VPWR _104_ sky130_fd_sc_hd__a211o_1
X_487_ net6 _411_ VGND VGND VPWR VPWR _420_ sky130_fd_sc_hd__nor2_1
X_556_ _033_ _034_ VGND VGND VPWR VPWR _035_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_1_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_608_ _084_ _085_ _086_ VGND VGND VPWR VPWR _087_ sky130_fd_sc_hd__o21a_1
XFILLER_0_24_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_539_ _015_ _016_ VGND VGND VPWR VPWR _018_ sky130_fd_sc_hd__nor2_1
XFILLER_0_6_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_890_ _374_ _375_ VGND VGND VPWR VPWR _376_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_19_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_76 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_873_ _340_ _341_ VGND VGND VPWR VPWR _358_ sky130_fd_sc_hd__nand2_1
XFILLER_0_41_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_856_ _337_ _338_ _339_ VGND VGND VPWR VPWR _340_ sky130_fd_sc_hd__o21a_1
XFILLER_0_16_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_787_ net6 _406_ _291_ VGND VGND VPWR VPWR _266_ sky130_fd_sc_hd__mux2_1
XFILLER_0_29_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput25 net25 VGND VGND VPWR VPWR product[2] sky130_fd_sc_hd__clkbuf_4
X_572_ _048_ _049_ VGND VGND VPWR VPWR _051_ sky130_fd_sc_hd__nor2_1
X_641_ _107_ _119_ VGND VGND VPWR VPWR _120_ sky130_fd_sc_hd__xnor2_1
X_710_ _270_ _179_ _186_ _187_ VGND VGND VPWR VPWR _188_ sky130_fd_sc_hd__o22a_1
XFILLER_0_26_228 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_908_ _145_ _389_ _393_ _390_ VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__a31o_1
XTAP_106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_839_ _319_ _320_ VGND VGND VPWR VPWR _322_ sky130_fd_sc_hd__nand2_1
XPHY_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_111 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_624_ _073_ _099_ VGND VGND VPWR VPWR _103_ sky130_fd_sc_hd__nand2_2
X_555_ _404_ _408_ _334_ VGND VGND VPWR VPWR _034_ sky130_fd_sc_hd__mux2_1
X_486_ _377_ _417_ _418_ VGND VGND VPWR VPWR _419_ sky130_fd_sc_hd__and3_1
XFILLER_0_13_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_220 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_607_ _039_ _053_ _054_ _356_ VGND VGND VPWR VPWR _086_ sky130_fd_sc_hd__a211o_1
X_538_ _016_ _015_ VGND VGND VPWR VPWR _017_ sky130_fd_sc_hd__and2_4
XFILLER_0_24_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_469_ _387_ VGND VGND VPWR VPWR _395_ sky130_fd_sc_hd__buf_8
XFILLER_0_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_164 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_872_ _145_ _348_ _355_ _357_ VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_21_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_134 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_855_ _324_ _333_ VGND VGND VPWR VPWR _339_ sky130_fd_sc_hd__nand2_1
X_786_ _262_ _263_ _264_ VGND VGND VPWR VPWR _265_ sky130_fd_sc_hd__o21a_1
XFILLER_0_29_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput26 net26 VGND VGND VPWR VPWR product[3] sky130_fd_sc_hd__clkbuf_4
X_640_ _112_ _117_ _118_ VGND VGND VPWR VPWR _119_ sky130_fd_sc_hd__o21ai_1
X_571_ _048_ _049_ VGND VGND VPWR VPWR _050_ sky130_fd_sc_hd__xor2_1
XTAP_129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_838_ _319_ _320_ VGND VGND VPWR VPWR _321_ sky130_fd_sc_hd__nor2_1
XTAP_118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_907_ _385_ _386_ _392_ _383_ VGND VGND VPWR VPWR _393_ sky130_fd_sc_hd__a211o_1
XTAP_107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_769_ _200_ _029_ _017_ _427_ VGND VGND VPWR VPWR _246_ sky130_fd_sc_hd__o22a_1
XFILLER_0_27_89 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_623_ _356_ VGND VGND VPWR VPWR _102_ sky130_fd_sc_hd__buf_2
X_485_ net7 _402_ VGND VGND VPWR VPWR _418_ sky130_fd_sc_hd__xor2_4
X_554_ _028_ _032_ _031_ _025_ VGND VGND VPWR VPWR _033_ sky130_fd_sc_hd__a2bb2o_2
XFILLER_0_38_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_606_ _055_ _043_ _052_ _069_ VGND VGND VPWR VPWR _085_ sky130_fd_sc_hd__a31o_1
X_537_ net6 _404_ net7 _395_ VGND VGND VPWR VPWR _016_ sky130_fd_sc_hd__or4_4
X_468_ net4 net3 net1 net2 VGND VGND VPWR VPWR _387_ sky130_fd_sc_hd__or4_4
XFILLER_0_10_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_102 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_871_ _353_ _354_ _143_ VGND VGND VPWR VPWR _357_ sky130_fd_sc_hd__o21a_1
XFILLER_0_21_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_79 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_854_ _330_ _336_ _196_ VGND VGND VPWR VPWR _338_ sky130_fd_sc_hd__o21ai_1
X_923_ _403_ VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__clkbuf_1
X_785_ _102_ _254_ _255_ _103_ VGND VGND VPWR VPWR _264_ sky130_fd_sc_hd__a211o_1
XFILLER_0_29_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_68 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_176 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput27 net27 VGND VGND VPWR VPWR product[4] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_11_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_570_ _438_ _000_ _334_ VGND VGND VPWR VPWR _049_ sky130_fd_sc_hd__mux2_1
XTAP_119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_837_ _404_ _408_ _141_ VGND VGND VPWR VPWR _320_ sky130_fd_sc_hd__mux2_1
X_906_ _391_ VGND VGND VPWR VPWR _392_ sky130_fd_sc_hd__inv_2
X_768_ net58 _207_ _244_ VGND VGND VPWR VPWR _245_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_27_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_67 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_699_ _148_ _176_ VGND VGND VPWR VPWR _177_ sky130_fd_sc_hd__xor2_1
XFILLER_0_40_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_622_ _097_ _075_ _077_ _100_ VGND VGND VPWR VPWR _101_ sky130_fd_sc_hd__a31o_1
X_484_ _402_ _405_ VGND VGND VPWR VPWR _417_ sky130_fd_sc_hd__nand2_2
XFILLER_0_13_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_553_ _430_ _014_ _027_ _031_ VGND VGND VPWR VPWR _032_ sky130_fd_sc_hd__a31o_1
X_605_ _055_ _043_ _052_ VGND VGND VPWR VPWR _084_ sky130_fd_sc_hd__a21oi_1
X_467_ net9 VGND VGND VPWR VPWR _377_ sky130_fd_sc_hd__buf_2
X_536_ net8 VGND VGND VPWR VPWR _015_ sky130_fd_sc_hd__inv_2
XFILLER_0_24_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_519_ _437_ _438_ VGND VGND VPWR VPWR _452_ sky130_fd_sc_hd__or2_1
XFILLER_0_27_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_870_ _353_ _354_ VGND VGND VPWR VPWR _355_ sky130_fd_sc_hd__nand2_1
XFILLER_0_1_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_853_ _330_ _336_ VGND VGND VPWR VPWR _337_ sky130_fd_sc_hd__and2_1
X_922_ _377_ _131_ VGND VGND VPWR VPWR _403_ sky130_fd_sc_hd__and2_1
XFILLER_0_16_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_784_ _257_ _260_ _261_ _100_ VGND VGND VPWR VPWR _263_ sky130_fd_sc_hd__a31o_1
XFILLER_0_12_106 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput28 net28 VGND VGND VPWR VPWR product[5] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_7_188 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_150 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput17 net17 VGND VGND VPWR VPWR product[0] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_34_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_905_ _200_ _017_ _141_ VGND VGND VPWR VPWR _391_ sky130_fd_sc_hd__mux2_1
XTAP_109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_836_ _137_ _315_ net54 _318_ VGND VGND VPWR VPWR _319_ sky130_fd_sc_hd__o31a_1
X_767_ _203_ _204_ VGND VGND VPWR VPWR _244_ sky130_fd_sc_hd__or2_1
XFILLER_0_27_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_698_ _174_ _175_ VGND VGND VPWR VPWR _176_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_40_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_621_ _073_ _099_ VGND VGND VPWR VPWR _100_ sky130_fd_sc_hd__and2_2
X_483_ _377_ _406_ _409_ _413_ _415_ VGND VGND VPWR VPWR _416_ sky130_fd_sc_hd__a32o_2
XFILLER_0_13_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_552_ _030_ VGND VGND VPWR VPWR _031_ sky130_fd_sc_hd__clkbuf_2
X_819_ _103_ _295_ VGND VGND VPWR VPWR _300_ sky130_fd_sc_hd__nor2_1
XFILLER_0_13_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_604_ _081_ _082_ VGND VGND VPWR VPWR _083_ sky130_fd_sc_hd__xor2_1
XFILLER_0_24_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_535_ _013_ _431_ VGND VGND VPWR VPWR _014_ sky130_fd_sc_hd__nand2b_4
XFILLER_0_39_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_131 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_466_ net9 net10 VGND VGND VPWR VPWR _366_ sky130_fd_sc_hd__xor2_4
XFILLER_0_10_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_25 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_518_ _449_ _450_ VGND VGND VPWR VPWR _451_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_27_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_192 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_921_ _400_ _401_ VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__xor2_1
XFILLER_0_14_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_852_ _333_ _335_ VGND VGND VPWR VPWR _336_ sky130_fd_sc_hd__xor2_1
XFILLER_0_16_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_783_ _257_ _260_ _261_ VGND VGND VPWR VPWR _262_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_37_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput18 net18 VGND VGND VPWR VPWR product[10] sky130_fd_sc_hd__clkbuf_4
Xoutput29 net29 VGND VGND VPWR VPWR product[6] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_11_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_904_ _145_ _388_ _389_ _390_ VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__a31o_1
X_835_ _137_ _317_ VGND VGND VPWR VPWR _318_ sky130_fd_sc_hd__nand2_1
X_766_ _222_ _224_ _242_ VGND VGND VPWR VPWR _243_ sky130_fd_sc_hd__a21o_1
X_697_ net56 _440_ _291_ VGND VGND VPWR VPWR _175_ sky130_fd_sc_hd__mux2_1
XPHY_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_620_ net13 net12 VGND VGND VPWR VPWR _099_ sky130_fd_sc_hd__or2b_1
X_551_ _427_ _029_ VGND VGND VPWR VPWR _030_ sky130_fd_sc_hd__and2_1
X_482_ _395_ _414_ VGND VGND VPWR VPWR _415_ sky130_fd_sc_hd__nand2_1
XFILLER_0_1_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_818_ _289_ _297_ _100_ VGND VGND VPWR VPWR _299_ sky130_fd_sc_hd__a21o_1
XFILLER_0_9_229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_749_ _324_ net42 VGND VGND VPWR VPWR _226_ sky130_fd_sc_hd__and2_1
XFILLER_0_0_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_143 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_465_ _334_ _345_ VGND VGND VPWR VPWR _356_ sky130_fd_sc_hd__nand2_2
X_603_ net59 _447_ _073_ VGND VGND VPWR VPWR _082_ sky130_fd_sc_hd__mux2_1
X_534_ _442_ _011_ _012_ VGND VGND VPWR VPWR _013_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_40_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_517_ _411_ _446_ _366_ _435_ VGND VGND VPWR VPWR _450_ sky130_fd_sc_hd__o211a_1
XFILLER_0_27_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_28 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_851_ _200_ _019_ _291_ VGND VGND VPWR VPWR _335_ sky130_fd_sc_hd__mux2_1
X_920_ _377_ _000_ VGND VGND VPWR VPWR _401_ sky130_fd_sc_hd__nand2_1
XFILLER_0_14_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_782_ _216_ _215_ _213_ VGND VGND VPWR VPWR _261_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_32_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput19 net19 VGND VGND VPWR VPWR product[11] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_2_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_903_ _143_ _381_ VGND VGND VPWR VPWR _390_ sky130_fd_sc_hd__nor2_1
X_834_ _196_ _307_ _308_ VGND VGND VPWR VPWR _317_ sky130_fd_sc_hd__a21oi_1
XPHY_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_765_ net43 _221_ VGND VGND VPWR VPWR _242_ sky130_fd_sc_hd__nor2_1
X_696_ _171_ _172_ _173_ VGND VGND VPWR VPWR _174_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_25_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_481_ _377_ _408_ VGND VGND VPWR VPWR _414_ sky130_fd_sc_hd__nand2_1
X_550_ _426_ net11 VGND VGND VPWR VPWR _029_ sky130_fd_sc_hd__or2_1
XFILLER_0_38_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_817_ _289_ _297_ VGND VGND VPWR VPWR _298_ sky130_fd_sc_hd__nor2_1
X_679_ _430_ _014_ _153_ _154_ _156_ VGND VGND VPWR VPWR _157_ sky130_fd_sc_hd__a311o_1
X_748_ _222_ _224_ VGND VGND VPWR VPWR _225_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_13_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_602_ _078_ _079_ _080_ VGND VGND VPWR VPWR _081_ sky130_fd_sc_hd__o21a_1
XFILLER_0_39_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_464_ net12 net11 VGND VGND VPWR VPWR _345_ sky130_fd_sc_hd__or2b_1
XFILLER_0_24_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_533_ _434_ _441_ VGND VGND VPWR VPWR _012_ sky130_fd_sc_hd__or2_1
XFILLER_0_40_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_147 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_103 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_516_ _439_ net9 _395_ VGND VGND VPWR VPWR _449_ sky130_fd_sc_hd__and3b_1
XFILLER_0_27_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_850_ _299_ _332_ _300_ VGND VGND VPWR VPWR _333_ sky130_fd_sc_hd__o21bai_2
X_781_ _070_ _254_ _256_ _258_ VGND VGND VPWR VPWR _260_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_16_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_61 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_175 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_902_ _385_ _386_ VGND VGND VPWR VPWR _389_ sky130_fd_sc_hd__nand2_1
X_833_ _310_ _312_ _314_ VGND VGND VPWR VPWR _316_ sky130_fd_sc_hd__and3_1
X_764_ _145_ _235_ _240_ _241_ VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__o22ai_4
XFILLER_0_43_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_695_ _102_ _164_ _165_ _103_ VGND VGND VPWR VPWR _173_ sky130_fd_sc_hd__a211o_1
XFILLER_0_4_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_480_ _410_ _412_ VGND VGND VPWR VPWR _413_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_38_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_816_ _295_ _296_ VGND VGND VPWR VPWR _297_ sky130_fd_sc_hd__xor2_1
X_747_ _148_ _176_ _223_ VGND VGND VPWR VPWR _224_ sky130_fd_sc_hd__a21o_1
X_678_ _152_ _155_ VGND VGND VPWR VPWR _156_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_13_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_175 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_601_ _039_ _063_ _064_ _356_ VGND VGND VPWR VPWR _080_ sky130_fd_sc_hd__a211o_1
XFILLER_0_39_178 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_463_ net11 net12 VGND VGND VPWR VPWR _334_ sky130_fd_sc_hd__nand2b_4
XFILLER_0_24_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_532_ _445_ _448_ _010_ VGND VGND VPWR VPWR _011_ sky130_fd_sc_hd__o21a_1
XFILLER_0_5_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_115 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_515_ net3 _447_ _427_ VGND VGND VPWR VPWR _448_ sky130_fd_sc_hd__mux2_1
XFILLER_0_27_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput1 multiplicand[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_36_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_90 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_780_ _102_ _247_ VGND VGND VPWR VPWR _258_ sky130_fd_sc_hd__or2_1
XFILLER_0_32_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_901_ _385_ _386_ VGND VGND VPWR VPWR _388_ sky130_fd_sc_hd__or2_1
X_832_ _310_ _312_ _314_ VGND VGND VPWR VPWR _315_ sky130_fd_sc_hd__a21oi_1
X_763_ _237_ _239_ _143_ VGND VGND VPWR VPWR _241_ sky130_fd_sc_hd__a21bo_1
X_694_ _167_ _169_ _170_ _100_ VGND VGND VPWR VPWR _172_ sky130_fd_sc_hd__a31o_1
XPHY_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_815_ _200_ _019_ _073_ VGND VGND VPWR VPWR _296_ sky130_fd_sc_hd__mux2_1
X_677_ net7 _418_ _427_ VGND VGND VPWR VPWR _155_ sky130_fd_sc_hd__mux2_1
X_746_ _175_ _174_ VGND VGND VPWR VPWR _223_ sky130_fd_sc_hd__and2b_1
XFILLER_0_0_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_531_ _002_ _008_ _009_ VGND VGND VPWR VPWR _010_ sky130_fd_sc_hd__o21ai_1
X_600_ _056_ _066_ _062_ _070_ VGND VGND VPWR VPWR _079_ sky130_fd_sc_hd__a31o_1
XFILLER_0_39_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_462_ _313_ VGND VGND VPWR VPWR _324_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_729_ _059_ _417_ _160_ _161_ VGND VGND VPWR VPWR _206_ sky130_fd_sc_hd__o211a_1
XFILLER_0_5_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_514_ _435_ _446_ VGND VGND VPWR VPWR _447_ sky130_fd_sc_hd__and2_2
XFILLER_0_27_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput2 multiplicand[1] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_91 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_900_ _373_ _375_ _372_ VGND VGND VPWR VPWR _386_ sky130_fd_sc_hd__a21o_1
X_831_ _274_ _275_ _272_ VGND VGND VPWR VPWR _314_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_43_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_762_ _237_ _239_ VGND VGND VPWR VPWR _240_ sky130_fd_sc_hd__nor2_1
XFILLER_0_27_19 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_693_ _167_ _169_ net52 VGND VGND VPWR VPWR _171_ sky130_fd_sc_hd__a21oi_1
XPHY_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_84 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_814_ _292_ _293_ _294_ VGND VGND VPWR VPWR _295_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_30_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_676_ _025_ _026_ VGND VGND VPWR VPWR _154_ sky130_fd_sc_hd__and2_1
X_745_ _220_ _221_ VGND VGND VPWR VPWR _222_ sky130_fd_sc_hd__xor2_1
X_461_ _291_ _302_ VGND VGND VPWR VPWR _313_ sky130_fd_sc_hd__and2_1
X_530_ _445_ _448_ VGND VGND VPWR VPWR _009_ sky130_fd_sc_hd__xor2_1
XFILLER_0_14_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_728_ _203_ _204_ VGND VGND VPWR VPWR _205_ sky130_fd_sc_hd__xnor2_4
X_659_ _130_ _134_ _137_ VGND VGND VPWR VPWR _138_ sky130_fd_sc_hd__a21o_1
XFILLER_0_5_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_513_ _437_ _438_ net3 VGND VGND VPWR VPWR _446_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_25_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_92 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput3 multiplicand[2] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__buf_12
XFILLER_0_14_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_52 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_830_ _324_ _307_ _311_ _309_ VGND VGND VPWR VPWR _312_ sky130_fd_sc_hd__o211ai_1
X_761_ _191_ _193_ _190_ VGND VGND VPWR VPWR _239_ sky130_fd_sc_hd__a21bo_1
XPHY_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_692_ _097_ _077_ _075_ VGND VGND VPWR VPWR _170_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_25_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_96 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_813_ _102_ _247_ VGND VGND VPWR VPWR _294_ sky130_fd_sc_hd__nor2_1
X_744_ _404_ _408_ _291_ VGND VGND VPWR VPWR _221_ sky130_fd_sc_hd__mux2_1
X_675_ _025_ _026_ VGND VGND VPWR VPWR _153_ sky130_fd_sc_hd__or2_1
XFILLER_0_0_145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_52 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_460_ net14 net13 VGND VGND VPWR VPWR _302_ sky130_fd_sc_hd__or2b_1
X_727_ net7 net40 _334_ VGND VGND VPWR VPWR _204_ sky130_fd_sc_hd__mux2_1
X_658_ _136_ VGND VGND VPWR VPWR _137_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_14_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_589_ _035_ _067_ VGND VGND VPWR VPWR _068_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_5_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_512_ _414_ _444_ VGND VGND VPWR VPWR _445_ sky130_fd_sc_hd__xor2_2
XFILLER_0_41_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput4 multiplicand[3] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__buf_6
XTAP_93 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_179 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_760_ _235_ _236_ VGND VGND VPWR VPWR _237_ sky130_fd_sc_hd__xor2_1
X_691_ _070_ _164_ _168_ _166_ VGND VGND VPWR VPWR _169_ sky130_fd_sc_hd__o211ai_2
X_889_ _352_ _354_ _350_ VGND VGND VPWR VPWR _375_ sky130_fd_sc_hd__a21o_1
XFILLER_0_3_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_230 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_812_ _247_ _290_ _070_ VGND VGND VPWR VPWR _293_ sky130_fd_sc_hd__a21o_1
X_674_ _407_ _018_ _151_ VGND VGND VPWR VPWR _152_ sky130_fd_sc_hd__a21oi_2
X_743_ _217_ _218_ _219_ VGND VGND VPWR VPWR _220_ sky130_fd_sc_hd__o21a_1
XFILLER_0_0_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_213 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_657_ _248_ _259_ VGND VGND VPWR VPWR _136_ sky130_fd_sc_hd__and2_1
X_726_ _197_ _198_ _202_ VGND VGND VPWR VPWR _203_ sky130_fd_sc_hd__mux2_4
XFILLER_0_5_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_588_ _056_ net50 _066_ VGND VGND VPWR VPWR _067_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_5_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_511_ _395_ _366_ _443_ VGND VGND VPWR VPWR _444_ sky130_fd_sc_hd__and3_1
XFILLER_0_18_108 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_709_ _182_ _184_ _185_ _137_ VGND VGND VPWR VPWR _187_ sky130_fd_sc_hd__a31o_1
XFILLER_0_41_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput5 multiplicand[4] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_94 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_690_ _070_ _160_ VGND VGND VPWR VPWR _168_ sky130_fd_sc_hd__nand2_1
XFILLER_0_40_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_888_ _372_ _373_ VGND VGND VPWR VPWR _374_ sky130_fd_sc_hd__or2b_1
XFILLER_0_17_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_811_ _245_ _251_ _290_ _247_ _252_ VGND VGND VPWR VPWR _292_ sky130_fd_sc_hd__o221a_1
XFILLER_0_30_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_673_ net8 net10 _003_ _017_ VGND VGND VPWR VPWR _151_ sky130_fd_sc_hd__o22a_2
X_742_ _102_ net45 _209_ _103_ VGND VGND VPWR VPWR _219_ sky130_fd_sc_hd__a211o_1
XFILLER_0_0_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_725_ _199_ _201_ VGND VGND VPWR VPWR _202_ sky130_fd_sc_hd__xnor2_1
X_656_ _130_ _134_ VGND VGND VPWR VPWR _135_ sky130_fd_sc_hd__nor2_1
X_587_ _039_ _063_ _064_ _065_ VGND VGND VPWR VPWR _066_ sky130_fd_sc_hd__a211o_1
XFILLER_0_5_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_510_ net10 _439_ VGND VGND VPWR VPWR _443_ sky130_fd_sc_hd__nand2_1
XFILLER_0_27_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_639_ _110_ _111_ VGND VGND VPWR VPWR _118_ sky130_fd_sc_hd__or2_1
XFILLER_0_41_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_708_ _182_ _184_ _185_ VGND VGND VPWR VPWR _186_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_41_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput6 multiplicand[5] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__clkbuf_4
XTAP_95 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_887_ _368_ _369_ _371_ VGND VGND VPWR VPWR _373_ sky130_fd_sc_hd__nand3_1
XFILLER_0_3_145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_810_ _059_ net41 _249_ VGND VGND VPWR VPWR _290_ sky130_fd_sc_hd__o21a_1
X_741_ _216_ _213_ _215_ _100_ VGND VGND VPWR VPWR _218_ sky130_fd_sc_hd__a31o_1
X_672_ _035_ _067_ _149_ VGND VGND VPWR VPWR _150_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_0_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_724_ _200_ _019_ _427_ VGND VGND VPWR VPWR _201_ sky130_fd_sc_hd__mux2_1
XFILLER_0_14_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_655_ _131_ _133_ VGND VGND VPWR VPWR _134_ sky130_fd_sc_hd__nand2_1
X_586_ _061_ VGND VGND VPWR VPWR _065_ sky130_fd_sc_hd__inv_2
XFILLER_0_38_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_187 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_12 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_707_ _129_ _134_ _126_ VGND VGND VPWR VPWR _185_ sky130_fd_sc_hd__a21o_1
X_638_ _116_ _437_ VGND VGND VPWR VPWR _117_ sky130_fd_sc_hd__and2b_1
XFILLER_0_41_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_569_ _010_ _047_ _038_ _445_ VGND VGND VPWR VPWR _048_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_41_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput7 multiplicand[6] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__buf_4
XTAP_96 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_219 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_886_ net47 _369_ _371_ VGND VGND VPWR VPWR _372_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_17_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_79 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput10 multiplier[1] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_3_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_740_ net34 _215_ net51 VGND VGND VPWR VPWR _217_ sky130_fd_sc_hd__a21oi_1
X_671_ _033_ _034_ VGND VGND VPWR VPWR _149_ sky130_fd_sc_hd__or2_1
X_869_ _322_ _325_ _321_ VGND VGND VPWR VPWR _354_ sky130_fd_sc_hd__a21o_1
XFILLER_0_8_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_55 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_119 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_654_ _110_ _132_ _127_ VGND VGND VPWR VPWR _133_ sky130_fd_sc_hd__mux2_2
X_723_ net8 VGND VGND VPWR VPWR _200_ sky130_fd_sc_hd__buf_2
XFILLER_0_38_163 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_585_ _039_ net49 VGND VGND VPWR VPWR _064_ sky130_fd_sc_hd__nor2_1
XTAP_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_199 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_637_ _100_ _114_ _115_ VGND VGND VPWR VPWR _116_ sky130_fd_sc_hd__o21a_1
XFILLER_0_25_24 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_706_ _127_ _177_ _183_ _181_ VGND VGND VPWR VPWR _184_ sky130_fd_sc_hd__a211o_1
XFILLER_0_41_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_499_ _413_ _415_ VGND VGND VPWR VPWR _432_ sky130_fd_sc_hd__and2_1
XFILLER_0_26_111 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_568_ _009_ _002_ _008_ _038_ VGND VGND VPWR VPWR _047_ sky130_fd_sc_hd__o31a_1
XFILLER_0_41_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput8 multiplicand[7] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_36_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_97 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_885_ net7 net40 _141_ VGND VGND VPWR VPWR _371_ sky130_fd_sc_hd__mux2_1
XFILLER_0_33_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput11 multiplier[2] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_16_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_670_ _146_ _119_ _147_ VGND VGND VPWR VPWR _148_ sky130_fd_sc_hd__a21o_1
XFILLER_0_21_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_868_ _350_ _352_ VGND VGND VPWR VPWR _353_ sky130_fd_sc_hd__and2b_1
X_799_ _137_ _276_ _277_ _278_ VGND VGND VPWR VPWR _279_ sky130_fd_sc_hd__o31a_1
XFILLER_0_8_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_653_ net37 _117_ VGND VGND VPWR VPWR _132_ sky130_fd_sc_hd__xnor2_1
X_722_ _152_ _155_ _157_ VGND VGND VPWR VPWR _199_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_38_175 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_584_ _431_ _013_ VGND VGND VPWR VPWR _063_ sky130_fd_sc_hd__xor2_1
XFILLER_0_39_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_231 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_567_ _437_ _045_ VGND VGND VPWR VPWR _046_ sky130_fd_sc_hd__nand2_1
X_636_ _100_ _087_ VGND VGND VPWR VPWR _115_ sky130_fd_sc_hd__nand2_1
XFILLER_0_25_36 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_705_ _313_ net38 VGND VGND VPWR VPWR _183_ sky130_fd_sc_hd__and2_1
XFILLER_0_41_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_123 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_498_ _425_ _429_ VGND VGND VPWR VPWR _431_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_1_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput9 multiplier[0] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__buf_2
X_619_ _075_ _077_ _097_ VGND VGND VPWR VPWR _098_ sky130_fd_sc_hd__a21oi_1
XTAP_98 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_112 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_884_ net46 _369_ VGND VGND VPWR VPWR _370_ sky130_fd_sc_hd__nand2_1
XFILLER_0_3_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput12 multiplier[3] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__buf_2
XFILLER_0_15_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_867_ _270_ _346_ _351_ _349_ VGND VGND VPWR VPWR _352_ sky130_fd_sc_hd__a211o_1
X_798_ _196_ net35 _269_ _270_ VGND VGND VPWR VPWR _278_ sky130_fd_sc_hd__a211o_1
XFILLER_0_12_224 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_652_ _437_ VGND VGND VPWR VPWR _131_ sky130_fd_sc_hd__buf_4
X_721_ _039_ _151_ VGND VGND VPWR VPWR _198_ sky130_fd_sc_hd__xnor2_1
X_583_ _014_ _057_ _058_ _061_ VGND VGND VPWR VPWR _062_ sky130_fd_sc_hd__a211o_1
XFILLER_0_38_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_919_ _131_ _366_ VGND VGND VPWR VPWR _400_ sky130_fd_sc_hd__nand2_1
XTAP_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_704_ _324_ net53 _178_ _181_ VGND VGND VPWR VPWR _182_ sky130_fd_sc_hd__o211ai_2
X_635_ _113_ _093_ VGND VGND VPWR VPWR _114_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_25_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_566_ _038_ _451_ _008_ _044_ VGND VGND VPWR VPWR _045_ sky130_fd_sc_hd__o22a_1
XFILLER_0_41_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_497_ _425_ _429_ VGND VGND VPWR VPWR _430_ sky130_fd_sc_hd__nand2_1
XFILLER_0_5_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_190 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_47 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_618_ _083_ _095_ _096_ VGND VGND VPWR VPWR _097_ sky130_fd_sc_hd__a21o_1
XTAP_88 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_99 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_549_ _430_ _014_ _027_ VGND VGND VPWR VPWR _028_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_14_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_49 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_222 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_163 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_883_ _137_ _363_ VGND VGND VPWR VPWR _369_ sky130_fd_sc_hd__nand2_1
XFILLER_0_33_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput13 multiplier[4] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_33_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_866_ _270_ _340_ VGND VGND VPWR VPWR _351_ sky130_fd_sc_hd__nor2_1
X_797_ _272_ _274_ _275_ VGND VGND VPWR VPWR _277_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_12_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_720_ _151_ VGND VGND VPWR VPWR _197_ sky130_fd_sc_hd__inv_2
XFILLER_0_38_111 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_582_ _059_ _440_ _060_ VGND VGND VPWR VPWR _061_ sky130_fd_sc_hd__o21ai_2
X_651_ _126_ _129_ VGND VGND VPWR VPWR _130_ sky130_fd_sc_hd__and2b_1
XFILLER_0_39_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_918_ _006_ _399_ VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__xor2_1
X_849_ _295_ _331_ VGND VGND VPWR VPWR _332_ sky130_fd_sc_hd__and2_1
XFILLER_0_29_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_634_ _094_ _089_ VGND VGND VPWR VPWR _113_ sky130_fd_sc_hd__or2b_1
X_703_ _180_ VGND VGND VPWR VPWR _181_ sky130_fd_sc_hd__inv_2
X_565_ _437_ _007_ _006_ _031_ VGND VGND VPWR VPWR _044_ sky130_fd_sc_hd__a31o_1
X_496_ _428_ VGND VGND VPWR VPWR _429_ sky130_fd_sc_hd__inv_2
XFILLER_0_1_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_617_ _081_ _082_ VGND VGND VPWR VPWR _096_ sky130_fd_sc_hd__nor2_1
XFILLER_0_36_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_479_ _404_ _408_ _411_ VGND VGND VPWR VPWR _412_ sky130_fd_sc_hd__mux2_1
XTAP_89 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_548_ _025_ _026_ VGND VGND VPWR VPWR _027_ sky130_fd_sc_hd__xor2_1
XFILLER_0_22_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_94 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_882_ _248_ _259_ _360_ _365_ _367_ VGND VGND VPWR VPWR _368_ sky130_fd_sc_hd__a221o_1
Xinput14 multiplier[5] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_3_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_865_ _137_ _346_ _347_ _349_ VGND VGND VPWR VPWR _350_ sky130_fd_sc_hd__o211a_1
X_796_ _272_ _274_ _275_ VGND VGND VPWR VPWR _276_ sky130_fd_sc_hd__and3_1
XFILLER_0_8_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_650_ _127_ _120_ _128_ _125_ VGND VGND VPWR VPWR _129_ sky130_fd_sc_hd__a211o_1
XFILLER_0_38_123 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_581_ net4 _334_ VGND VGND VPWR VPWR _060_ sky130_fd_sc_hd__or2_1
XFILLER_0_39_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_917_ _131_ _039_ VGND VGND VPWR VPWR _399_ sky130_fd_sc_hd__nand2_1
X_848_ _200_ net41 _073_ VGND VGND VPWR VPWR _331_ sky130_fd_sc_hd__mux2_1
X_779_ _102_ _254_ _255_ _256_ VGND VGND VPWR VPWR _257_ sky130_fd_sc_hd__a211o_1
XFILLER_0_20_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_70 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_633_ _110_ _111_ VGND VGND VPWR VPWR _112_ sky130_fd_sc_hd__xnor2_1
X_702_ net59 _447_ _238_ VGND VGND VPWR VPWR _180_ sky130_fd_sc_hd__mux2_1
X_564_ _036_ _037_ _040_ _042_ VGND VGND VPWR VPWR _043_ sky130_fd_sc_hd__a211o_1
X_495_ _404_ _408_ _427_ VGND VGND VPWR VPWR _428_ sky130_fd_sc_hd__mux2_1
XFILLER_0_1_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_616_ _089_ _093_ _094_ VGND VGND VPWR VPWR _095_ sky130_fd_sc_hd__a21o_1
X_547_ net6 _406_ _427_ VGND VGND VPWR VPWR _026_ sky130_fd_sc_hd__mux2_1
X_478_ net9 net10 VGND VGND VPWR VPWR _411_ sky130_fd_sc_hd__or2b_2
XFILLER_0_9_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_881_ _358_ net44 _365_ _359_ VGND VGND VPWR VPWR _367_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_24_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput15 multiplier[6] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_15_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_864_ _210_ _417_ _141_ VGND VGND VPWR VPWR _349_ sky130_fd_sc_hd__mux2_1
X_795_ _230_ _231_ _228_ VGND VGND VPWR VPWR _275_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_12_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_580_ net11 net12 VGND VGND VPWR VPWR _059_ sky130_fd_sc_hd__nor2b_2
XFILLER_0_38_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_916_ _045_ _398_ VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__xor2_1
XFILLER_0_39_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_847_ _328_ _306_ _329_ VGND VGND VPWR VPWR _330_ sky130_fd_sc_hd__o21a_1
X_778_ net7 net40 _073_ VGND VGND VPWR VPWR _256_ sky130_fd_sc_hd__mux2_1
XFILLER_0_29_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_82 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_632_ _438_ _000_ _291_ VGND VGND VPWR VPWR _111_ sky130_fd_sc_hd__mux2_1
X_563_ _041_ VGND VGND VPWR VPWR _042_ sky130_fd_sc_hd__inv_2
X_701_ _324_ _177_ _178_ VGND VGND VPWR VPWR _179_ sky130_fd_sc_hd__o21ai_1
X_494_ _426_ net11 VGND VGND VPWR VPWR _427_ sky130_fd_sc_hd__nand2_4
XFILLER_0_26_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_615_ _087_ _088_ VGND VGND VPWR VPWR _094_ sky130_fd_sc_hd__nor2_1
X_546_ _020_ _024_ _366_ VGND VGND VPWR VPWR _025_ sky130_fd_sc_hd__mux2_4
X_477_ net9 _402_ _405_ VGND VGND VPWR VPWR _410_ sky130_fd_sc_hd__and3_4
XFILLER_0_22_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_529_ _437_ _006_ _007_ VGND VGND VPWR VPWR _008_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_42_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_222 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_880_ _363_ _364_ VGND VGND VPWR VPWR _365_ sky130_fd_sc_hd__xnor2_1
Xinput16 multiplier[7] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__buf_1
XFILLER_0_15_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_863_ _137_ _346_ _347_ VGND VGND VPWR VPWR _348_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_28_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_794_ _324_ _268_ _273_ _271_ VGND VGND VPWR VPWR _274_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_34_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_915_ _131_ _102_ VGND VGND VPWR VPWR _398_ sky130_fd_sc_hd__nand2_1
X_846_ _301_ _303_ VGND VGND VPWR VPWR _329_ sky130_fd_sc_hd__or2_1
XTAP_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_777_ _070_ _247_ VGND VGND VPWR VPWR _255_ sky130_fd_sc_hd__and2_1
XFILLER_0_37_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_700_ _127_ net39 VGND VGND VPWR VPWR _178_ sky130_fd_sc_hd__or2_1
X_631_ _103_ _081_ _108_ _109_ VGND VGND VPWR VPWR _110_ sky130_fd_sc_hd__o22a_1
X_562_ net59 _447_ _334_ VGND VGND VPWR VPWR _041_ sky130_fd_sc_hd__mux2_1
X_493_ net10 VGND VGND VPWR VPWR _426_ sky130_fd_sc_hd__inv_2
XFILLER_0_26_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_829_ _196_ _301_ VGND VGND VPWR VPWR _311_ sky130_fd_sc_hd__or2_1
XFILLER_0_25_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_614_ _437_ _092_ VGND VGND VPWR VPWR _093_ sky130_fd_sc_hd__nand2_1
X_476_ _407_ _408_ VGND VGND VPWR VPWR _409_ sky130_fd_sc_hd__nor2_1
X_545_ _021_ _023_ VGND VGND VPWR VPWR _024_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_14_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_459_ _281_ VGND VGND VPWR VPWR _291_ sky130_fd_sc_hd__clkbuf_4
X_528_ _451_ _001_ VGND VGND VPWR VPWR _007_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_27_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_862_ _137_ _340_ VGND VGND VPWR VPWR _347_ sky130_fd_sc_hd__nand2_1
X_793_ _196_ _265_ VGND VGND VPWR VPWR _273_ sky130_fd_sc_hd__or2_1
XFILLER_0_20_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_96 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_914_ _092_ _397_ VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__xor2_1
X_845_ _301_ _303_ VGND VGND VPWR VPWR _328_ sky130_fd_sc_hd__and2_1
X_776_ _245_ _253_ VGND VGND VPWR VPWR _254_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_20_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_630_ _083_ _095_ _100_ VGND VGND VPWR VPWR _109_ sky130_fd_sc_hd__a21o_1
X_561_ _039_ _434_ VGND VGND VPWR VPWR _040_ sky130_fd_sc_hd__nor2_1
X_492_ _366_ _423_ _424_ VGND VGND VPWR VPWR _425_ sky130_fd_sc_hd__a21o_1
XFILLER_0_34_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_828_ _196_ _307_ _308_ _309_ VGND VGND VPWR VPWR _310_ sky130_fd_sc_hd__a211o_1
X_759_ net59 _447_ _141_ VGND VGND VPWR VPWR _236_ sky130_fd_sc_hd__mux2_1
XFILLER_0_15_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_613_ _356_ _048_ _090_ _091_ VGND VGND VPWR VPWR _092_ sky130_fd_sc_hd__o22a_1
XFILLER_0_39_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_475_ _404_ _395_ VGND VGND VPWR VPWR _408_ sky130_fd_sc_hd__xor2_4
X_544_ _020_ _022_ VGND VGND VPWR VPWR _023_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_22_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_527_ _377_ _426_ _452_ _447_ _005_ VGND VGND VPWR VPWR _006_ sky130_fd_sc_hd__a41o_1
X_458_ net13 net14 VGND VGND VPWR VPWR _281_ sky130_fd_sc_hd__or2b_1
XFILLER_0_27_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_84 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_216 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_861_ _342_ _344_ VGND VGND VPWR VPWR _346_ sky130_fd_sc_hd__xnor2_1
X_792_ _196_ _268_ _269_ _271_ VGND VGND VPWR VPWR _272_ sky130_fd_sc_hd__a211o_1
XFILLER_0_8_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_913_ _131_ _103_ VGND VGND VPWR VPWR _397_ sky130_fd_sc_hd__nand2_1
X_844_ _145_ _326_ _327_ VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__a21o_1
X_775_ _251_ _252_ VGND VGND VPWR VPWR _253_ sky130_fd_sc_hd__and2b_1
XFILLER_0_29_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_560_ _038_ VGND VGND VPWR VPWR _039_ sky130_fd_sc_hd__clkbuf_4
X_491_ _377_ net10 _418_ VGND VGND VPWR VPWR _424_ sky130_fd_sc_hd__and3_1
XFILLER_0_34_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_827_ net6 _406_ _248_ VGND VGND VPWR VPWR _309_ sky130_fd_sc_hd__mux2_1
XFILLER_0_15_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_758_ _232_ _233_ _234_ VGND VGND VPWR VPWR _235_ sky130_fd_sc_hd__o21a_1
X_689_ _356_ _164_ _165_ _166_ VGND VGND VPWR VPWR _167_ sky130_fd_sc_hd__a211o_1
XFILLER_0_31_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_612_ _046_ _050_ _069_ VGND VGND VPWR VPWR _091_ sky130_fd_sc_hd__a21o_1
X_543_ net7 _418_ _411_ VGND VGND VPWR VPWR _022_ sky130_fd_sc_hd__mux2_1
X_474_ net9 net10 VGND VGND VPWR VPWR _407_ sky130_fd_sc_hd__and2b_1
XFILLER_0_22_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_526_ _377_ _447_ _004_ _452_ VGND VGND VPWR VPWR _005_ sky130_fd_sc_hd__a22oi_1
X_457_ _248_ _259_ VGND VGND VPWR VPWR _270_ sky130_fd_sc_hd__nand2_4
XFILLER_0_12_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_96 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_228 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_509_ _434_ _441_ VGND VGND VPWR VPWR _442_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_2_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_860_ _317_ _343_ _316_ VGND VGND VPWR VPWR _344_ sky130_fd_sc_hd__a21o_1
X_791_ _404_ _408_ _248_ VGND VGND VPWR VPWR _271_ sky130_fd_sc_hd__mux2_1
XFILLER_0_7_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_912_ _116_ _396_ VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__xnor2_1
X_843_ _145_ _319_ VGND VGND VPWR VPWR _327_ sky130_fd_sc_hd__nor2_1
X_774_ _247_ _250_ VGND VGND VPWR VPWR _252_ sky130_fd_sc_hd__nand2_1
XFILLER_0_20_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_175 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xsplit24 net4 VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__clkbuf_2
X_490_ _416_ _422_ VGND VGND VPWR VPWR _423_ sky130_fd_sc_hd__xor2_1
XFILLER_0_19_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_826_ _324_ _301_ VGND VGND VPWR VPWR _308_ sky130_fd_sc_hd__and2_1
XFILLER_0_15_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_757_ _196_ net33 _226_ _270_ VGND VGND VPWR VPWR _234_ sky130_fd_sc_hd__a211o_1
X_688_ _404_ _408_ _073_ VGND VGND VPWR VPWR _166_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_611_ _046_ _050_ VGND VGND VPWR VPWR _090_ sky130_fd_sc_hd__nor2_1
X_473_ _402_ _405_ VGND VGND VPWR VPWR _406_ sky130_fd_sc_hd__and2_2
X_542_ _416_ _421_ _419_ VGND VGND VPWR VPWR _021_ sky130_fd_sc_hd__a21oi_2
X_809_ _260_ _261_ _257_ VGND VGND VPWR VPWR _289_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_26_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer20 _170_ VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__clkbuf_1
XPHY_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_456_ net15 net14 VGND VGND VPWR VPWR _259_ sky130_fd_sc_hd__or2b_2
X_525_ _407_ _453_ _003_ VGND VGND VPWR VPWR _004_ sky130_fd_sc_hd__a21o_1
XFILLER_0_12_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_508_ net4 _440_ _427_ VGND VGND VPWR VPWR _441_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_790_ _324_ _265_ VGND VGND VPWR VPWR _269_ sky130_fd_sc_hd__and2_1
XFILLER_0_20_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_54 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_911_ _131_ _196_ VGND VGND VPWR VPWR _396_ sky130_fd_sc_hd__nand2_1
X_842_ _323_ _325_ VGND VGND VPWR VPWR _326_ sky130_fd_sc_hd__xnor2_1
X_773_ _247_ _250_ VGND VGND VPWR VPWR _251_ sky130_fd_sc_hd__nor2_1
XFILLER_0_37_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_66 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_31 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xsplit25 net3 VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_19_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_825_ _304_ _306_ VGND VGND VPWR VPWR _307_ sky130_fd_sc_hd__xnor2_1
X_756_ _228_ _230_ _231_ _137_ VGND VGND VPWR VPWR _233_ sky130_fd_sc_hd__a31o_1
XFILLER_0_15_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_687_ _356_ _160_ VGND VGND VPWR VPWR _165_ sky130_fd_sc_hd__nor2_1
XFILLER_0_31_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_168 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_610_ _087_ _088_ VGND VGND VPWR VPWR _089_ sky130_fd_sc_hd__nand2_1
XFILLER_0_39_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_472_ _404_ _395_ net6 VGND VGND VPWR VPWR _405_ sky130_fd_sc_hd__o21ai_1
X_541_ _377_ _019_ VGND VGND VPWR VPWR _020_ sky130_fd_sc_hd__nand2_1
X_808_ _145_ _287_ _288_ VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__a21o_1
XFILLER_0_26_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_739_ _169_ _170_ _167_ VGND VGND VPWR VPWR _216_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_42_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer10 _220_ VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__clkbuf_1
XPHY_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer21 _177_ VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_36_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_524_ net10 net9 VGND VGND VPWR VPWR _003_ sky130_fd_sc_hd__and2b_1
XFILLER_0_27_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_455_ _238_ VGND VGND VPWR VPWR _248_ sky130_fd_sc_hd__buf_4
XFILLER_0_10_116 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_507_ _436_ _439_ VGND VGND VPWR VPWR _440_ sky130_fd_sc_hd__nor2_2
XFILLER_0_23_67 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer1 _225_ VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_20_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_910_ _133_ _394_ VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__xor2_1
X_772_ _059_ _019_ _249_ VGND VGND VPWR VPWR _250_ sky130_fd_sc_hd__o21a_1
X_841_ _283_ _286_ _282_ VGND VGND VPWR VPWR _325_ sky130_fd_sc_hd__a21o_1
XFILLER_0_37_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_219 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_166 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_824_ _243_ _267_ _305_ VGND VGND VPWR VPWR _306_ sky130_fd_sc_hd__a21oi_2
X_755_ _228_ _230_ _231_ VGND VGND VPWR VPWR _232_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_15_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_686_ _150_ _163_ VGND VGND VPWR VPWR _164_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_31_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_540_ _017_ _018_ VGND VGND VPWR VPWR _019_ sky130_fd_sc_hd__or2_4
XFILLER_0_39_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_471_ net5 VGND VGND VPWR VPWR _404_ sky130_fd_sc_hd__buf_4
X_669_ _105_ _106_ VGND VGND VPWR VPWR _147_ sky130_fd_sc_hd__nor2_1
X_807_ _145_ _279_ VGND VGND VPWR VPWR _288_ sky130_fd_sc_hd__nor2_1
X_738_ _070_ _208_ _214_ _212_ VGND VGND VPWR VPWR _215_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_42_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer11 _220_ VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__clkbuf_1
XPHY_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer22 _316_ VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__clkbuf_1
XPHY_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_523_ _451_ _001_ VGND VGND VPWR VPWR _002_ sky130_fd_sc_hd__nor2_1
XFILLER_0_35_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_454_ net14 net15 VGND VGND VPWR VPWR _238_ sky130_fd_sc_hd__or2b_1
XFILLER_0_27_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_506_ net3 _437_ _438_ net4 VGND VGND VPWR VPWR _439_ sky130_fd_sc_hd__o31a_1
XFILLER_0_23_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer2 _213_ VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_114 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_840_ _321_ _322_ VGND VGND VPWR VPWR _323_ sky130_fd_sc_hd__or2b_1
X_771_ _015_ _059_ VGND VGND VPWR VPWR _249_ sky130_fd_sc_hd__nand2_1
XFILLER_0_37_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_164 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_823_ _265_ _266_ VGND VGND VPWR VPWR _305_ sky130_fd_sc_hd__nor2_1
X_754_ _184_ _185_ _182_ VGND VGND VPWR VPWR _231_ sky130_fd_sc_hd__a21bo_1
X_685_ _160_ _162_ VGND VGND VPWR VPWR _163_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_15_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_470_ net6 net5 _395_ VGND VGND VPWR VPWR _402_ sky130_fd_sc_hd__or3_4
X_806_ _284_ _286_ VGND VGND VPWR VPWR _287_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_30_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_668_ _105_ _106_ VGND VGND VPWR VPWR _146_ sky130_fd_sc_hd__nand2_1
X_599_ _066_ net50 _056_ VGND VGND VPWR VPWR _078_ sky130_fd_sc_hd__a21oi_1
X_737_ _102_ _203_ VGND VGND VPWR VPWR _214_ sky130_fd_sc_hd__or2_1
XFILLER_0_13_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer12 _344_ VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_13_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer23 _225_ VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__clkbuf_1
XPHY_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_522_ _438_ _000_ _427_ VGND VGND VPWR VPWR _001_ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_505_ net2 VGND VGND VPWR VPWR _438_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_2_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer3 _268_ VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_23_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_14 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_770_ _039_ _151_ _246_ VGND VGND VPWR VPWR _247_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_37_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_899_ _383_ _384_ VGND VGND VPWR VPWR _385_ sky130_fd_sc_hd__nor2_1
XFILLER_0_43_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_176 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_822_ _301_ _303_ VGND VGND VPWR VPWR _304_ sky130_fd_sc_hd__xnor2_1
X_753_ _324_ net55 _229_ _227_ VGND VGND VPWR VPWR _230_ sky130_fd_sc_hd__o211ai_2
X_684_ _059_ _417_ _161_ VGND VGND VPWR VPWR _162_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_25_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_116 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_805_ _237_ _239_ _285_ VGND VGND VPWR VPWR _286_ sky130_fd_sc_hd__a21o_1
X_736_ _102_ _208_ _209_ _212_ VGND VGND VPWR VPWR _213_ sky130_fd_sc_hd__a211o_1
X_667_ _143_ VGND VGND VPWR VPWR _145_ sky130_fd_sc_hd__clkbuf_4
X_598_ _070_ _068_ _076_ _074_ VGND VGND VPWR VPWR _077_ sky130_fd_sc_hd__o211ai_2
XPHY_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer13 _208_ VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__clkbuf_1
Xrebuffer24 _205_ VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__clkbuf_1
XPHY_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_521_ _452_ _453_ VGND VGND VPWR VPWR _000_ sky130_fd_sc_hd__and2_2
XFILLER_0_12_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_719_ _127_ VGND VGND VPWR VPWR _196_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_5_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_504_ net1 VGND VGND VPWR VPWR _437_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_23_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xrebuffer4 _120_ VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_898_ _381_ _382_ VGND VGND VPWR VPWR _384_ sky130_fd_sc_hd__and2_1
XFILLER_0_43_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_821_ net7 net40 _291_ VGND VGND VPWR VPWR _303_ sky130_fd_sc_hd__mux2_1
X_752_ _127_ net42 VGND VGND VPWR VPWR _229_ sky130_fd_sc_hd__or2_1
X_683_ net6 _059_ VGND VGND VPWR VPWR _161_ sky130_fd_sc_hd__nand2_1
XFILLER_0_25_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_735_ _211_ VGND VGND VPWR VPWR _212_ sky130_fd_sc_hd__inv_2
X_804_ _235_ _236_ VGND VGND VPWR VPWR _285_ sky130_fd_sc_hd__nor2_1
XFILLER_0_26_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_666_ _139_ _144_ VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__xor2_1
X_597_ _356_ _033_ VGND VGND VPWR VPWR _076_ sky130_fd_sc_hd__or2_1
XFILLER_0_21_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer14 _368_ VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__clkbuf_1
XPHY_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_172 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_520_ _437_ _438_ VGND VGND VPWR VPWR _453_ sky130_fd_sc_hd__nand2_1
XFILLER_0_35_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_649_ _127_ _105_ VGND VGND VPWR VPWR _128_ sky130_fd_sc_hd__nor2_1
X_718_ _145_ _194_ _195_ VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__a21o_1
XFILLER_0_5_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_503_ net4 _435_ VGND VGND VPWR VPWR _436_ sky130_fd_sc_hd__nor2_1
Xrebuffer5 _112_ VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_897_ _381_ _382_ VGND VGND VPWR VPWR _383_ sky130_fd_sc_hd__nor2_1
XFILLER_0_28_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_820_ _298_ _299_ _300_ VGND VGND VPWR VPWR _301_ sky130_fd_sc_hd__o21ba_1
X_682_ _039_ _152_ _157_ _159_ VGND VGND VPWR VPWR _160_ sky130_fd_sc_hd__a2bb2o_2
X_751_ _196_ _225_ _226_ _227_ VGND VGND VPWR VPWR _228_ sky130_fd_sc_hd__a211o_1
XFILLER_0_25_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_734_ _210_ _417_ _073_ VGND VGND VPWR VPWR _211_ sky130_fd_sc_hd__mux2_1
X_803_ _282_ _283_ VGND VGND VPWR VPWR _284_ sky130_fd_sc_hd__or2b_1
X_665_ _131_ _143_ VGND VGND VPWR VPWR _144_ sky130_fd_sc_hd__nand2_1
XFILLER_0_26_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_596_ _356_ _068_ _071_ _074_ VGND VGND VPWR VPWR _075_ sky130_fd_sc_hd__a211o_1
XFILLER_0_6_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer15 _368_ VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__clkbuf_1
XPHY_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_648_ _291_ _302_ VGND VGND VPWR VPWR _127_ sky130_fd_sc_hd__nand2_2
X_717_ _145_ _188_ VGND VGND VPWR VPWR _195_ sky130_fd_sc_hd__nor2_1
XFILLER_0_41_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_579_ _031_ net48 VGND VGND VPWR VPWR _058_ sky130_fd_sc_hd__and2_1
XFILLER_0_5_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_502_ net3 net1 net2 VGND VGND VPWR VPWR _435_ sky130_fd_sc_hd__or3_1
XFILLER_0_23_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer6 _174_ VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_83 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_179 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_896_ _200_ _019_ _141_ VGND VGND VPWR VPWR _382_ sky130_fd_sc_hd__mux2_1
XFILLER_0_3_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_681_ _156_ _158_ _031_ VGND VGND VPWR VPWR _159_ sky130_fd_sc_hd__a21oi_1
X_750_ net56 _440_ _248_ VGND VGND VPWR VPWR _227_ sky130_fd_sc_hd__mux2_1
XFILLER_0_31_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_879_ _200_ _019_ _248_ VGND VGND VPWR VPWR _364_ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_802_ _279_ _280_ VGND VGND VPWR VPWR _283_ sky130_fd_sc_hd__nand2_1
XFILLER_0_30_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_664_ _141_ _142_ VGND VGND VPWR VPWR _143_ sky130_fd_sc_hd__nand2_2
X_733_ net6 VGND VGND VPWR VPWR _210_ sky130_fd_sc_hd__inv_2
X_595_ net56 _440_ _073_ VGND VGND VPWR VPWR _074_ sky130_fd_sc_hd__mux2_1
XFILLER_0_42_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer16 _425_ VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_16_94 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput30 net30 VGND VGND VPWR VPWR product[7] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_37_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_716_ _192_ _193_ VGND VGND VPWR VPWR _194_ sky130_fd_sc_hd__xnor2_1
X_578_ _012_ _036_ _431_ _031_ VGND VGND VPWR VPWR _057_ sky130_fd_sc_hd__a31oi_1
X_647_ _313_ _120_ _121_ _125_ VGND VGND VPWR VPWR _126_ sky130_fd_sc_hd__o211a_1
XFILLER_0_41_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
.ends
