* NGSPICE file created from baugh.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_6 abstract view
.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_4 abstract view
.subckt sky130_fd_sc_hd__or4_4 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_4 abstract view
.subckt sky130_fd_sc_hd__or3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_1 abstract view
.subckt sky130_fd_sc_hd__nand3b_1 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_1 abstract view
.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_1 abstract view
.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_1 abstract view
.subckt sky130_fd_sc_hd__a211oi_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_2 abstract view
.subckt sky130_fd_sc_hd__xnor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_1 abstract view
.subckt sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_2 abstract view
.subckt sky130_fd_sc_hd__o21bai_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_1 abstract view
.subckt sky130_fd_sc_hd__a22oi_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_4 abstract view
.subckt sky130_fd_sc_hd__or3b_4 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_2 abstract view
.subckt sky130_fd_sc_hd__nand4_2 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_1 abstract view
.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_2 abstract view
.subckt sky130_fd_sc_hd__a211oi_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_1 abstract view
.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4b_1 abstract view
.subckt sky130_fd_sc_hd__and4b_1 A_N B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_1 abstract view
.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_2 abstract view
.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_2 abstract view
.subckt sky130_fd_sc_hd__or3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_2 abstract view
.subckt sky130_fd_sc_hd__a31o_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_4 abstract view
.subckt sky130_fd_sc_hd__nand3_4 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_2 abstract view
.subckt sky130_fd_sc_hd__and4_2 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_1 abstract view
.subckt sky130_fd_sc_hd__nand4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4bb_1 abstract view
.subckt sky130_fd_sc_hd__and4bb_1 A_N B_N C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_4 abstract view
.subckt sky130_fd_sc_hd__and2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_2 abstract view
.subckt sky130_fd_sc_hd__o211ai_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_1 abstract view
.subckt sky130_fd_sc_hd__nor3b_1 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_1 abstract view
.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_4 abstract view
.subckt sky130_fd_sc_hd__a21oi_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_2 abstract view
.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_2 abstract view
.subckt sky130_fd_sc_hd__a22oi_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311ai_4 abstract view
.subckt sky130_fd_sc_hd__o311ai_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_1 abstract view
.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_1 abstract view
.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_8 abstract view
.subckt sky130_fd_sc_hd__buf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_2 abstract view
.subckt sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_2 abstract view
.subckt sky130_fd_sc_hd__nand3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32oi_2 abstract view
.subckt sky130_fd_sc_hd__a32oi_2 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_1 abstract view
.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4_1 abstract view
.subckt sky130_fd_sc_hd__nor4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_4 abstract view
.subckt sky130_fd_sc_hd__o21a_4 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_2 abstract view
.subckt sky130_fd_sc_hd__o31a_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_4 abstract view
.subckt sky130_fd_sc_hd__xnor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_2 abstract view
.subckt sky130_fd_sc_hd__o21ba_2 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

.subckt baugh A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] B[0] B[1] B[2] B[3] B[4] B[5]
+ B[6] B[7] P[0] P[10] P[11] P[12] P[13] P[14] P[15] P[1] P[2] P[3] P[4] P[5] P[6]
+ P[7] P[8] P[9] VGND VPWR
XTAP_177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_432_ _005_ _006_ VGND VGND VPWR VPWR _007_ sky130_fd_sc_hd__and2b_1
X_501_ _038_ _040_ _037_ VGND VGND VPWR VPWR _075_ sky130_fd_sc_hd__a21o_1
X_363_ net10 VGND VGND VPWR VPWR _286_ sky130_fd_sc_hd__buf_2
XFILLER_0_23_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer7 _109_ VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__buf_1
XFILLER_0_13_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_130 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_415_ net6 VGND VGND VPWR VPWR _348_ sky130_fd_sc_hd__buf_6
XFILLER_0_4_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_82 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_680_ _094_ _042_ _249_ VGND VGND VPWR VPWR _250_ sky130_fd_sc_hd__or3_1
XFILLER_0_0_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_663_ _190_ _231_ VGND VGND VPWR VPWR _232_ sky130_fd_sc_hd__xnor2_1
X_594_ net13 _094_ _134_ _311_ VGND VGND VPWR VPWR _165_ sky130_fd_sc_hd__a22o_1
XFILLER_0_16_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput31 net31 VGND VGND VPWR VPWR P[8] sky130_fd_sc_hd__clkbuf_4
Xoutput20 net20 VGND VGND VPWR VPWR P[12] sky130_fd_sc_hd__clkbuf_4
X_715_ _284_ _285_ VGND VGND VPWR VPWR _287_ sky130_fd_sc_hd__nand2_2
X_646_ _118_ _181_ _182_ _211_ VGND VGND VPWR VPWR _215_ sky130_fd_sc_hd__or4_4
X_577_ _121_ _147_ _148_ VGND VGND VPWR VPWR _149_ sky130_fd_sc_hd__or3_4
XTAP_112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_500_ _036_ _071_ _072_ VGND VGND VPWR VPWR _074_ sky130_fd_sc_hd__nand3b_1
X_362_ net2 VGND VGND VPWR VPWR _275_ sky130_fd_sc_hd__buf_2
X_431_ _003_ _004_ _345_ VGND VGND VPWR VPWR _006_ sky130_fd_sc_hd__a21o_1
Xrebuffer8 net40 VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__clkbuf_1
X_629_ _197_ _198_ VGND VGND VPWR VPWR _199_ sky130_fd_sc_hd__xor2_1
XFILLER_0_3_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_414_ net11 net4 VGND VGND VPWR VPWR _347_ sky130_fd_sc_hd__and2_1
XFILLER_0_24_40 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_94 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_19 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_662_ _226_ _230_ VGND VGND VPWR VPWR _231_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_26_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_731_ _008_ _301_ VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__xnor2_1
X_593_ net12 net13 net7 net8 VGND VGND VPWR VPWR _164_ sky130_fd_sc_hd__and4_1
XFILLER_0_6_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_115 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput21 net21 VGND VGND VPWR VPWR P[13] sky130_fd_sc_hd__clkbuf_4
Xoutput32 net32 VGND VGND VPWR VPWR P[9] sky130_fd_sc_hd__clkbuf_4
X_645_ _181_ _183_ _211_ _213_ VGND VGND VPWR VPWR _214_ sky130_fd_sc_hd__o31a_1
X_714_ _281_ _283_ VGND VGND VPWR VPWR _285_ sky130_fd_sc_hd__nand2_1
X_576_ _145_ _146_ _105_ _122_ VGND VGND VPWR VPWR _148_ sky130_fd_sc_hd__o211a_1
XTAP_113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_94 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_361_ _255_ VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__clkbuf_1
X_430_ _345_ _003_ _004_ VGND VGND VPWR VPWR _005_ sky130_fd_sc_hd__and3_1
Xrebuffer9 _051_ VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__clkbuf_1
X_628_ _094_ _000_ VGND VGND VPWR VPWR _198_ sky130_fd_sc_hd__nand2_1
X_559_ net12 net7 net6 net13 VGND VGND VPWR VPWR _131_ sky130_fd_sc_hd__a22o_1
XFILLER_0_38_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_413_ _330_ _332_ _333_ VGND VGND VPWR VPWR _346_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_34_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_52 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_96 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_661_ _228_ _229_ VGND VGND VPWR VPWR _230_ sky130_fd_sc_hd__nor2_1
X_592_ _124_ _162_ VGND VGND VPWR VPWR _163_ sky130_fd_sc_hd__xnor2_1
X_730_ _340_ _342_ VGND VGND VPWR VPWR _301_ sky130_fd_sc_hd__nand2_1
XFILLER_0_38_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput22 net22 VGND VGND VPWR VPWR P[14] sky130_fd_sc_hd__buf_6
XFILLER_0_9_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_644_ _179_ _210_ _209_ VGND VGND VPWR VPWR _213_ sky130_fd_sc_hd__a21o_1
X_713_ _281_ _283_ VGND VGND VPWR VPWR _284_ sky130_fd_sc_hd__or2_1
X_575_ _105_ _122_ _145_ _146_ VGND VGND VPWR VPWR _147_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_5_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_360_ _234_ _245_ VGND VGND VPWR VPWR _255_ sky130_fd_sc_hd__and2_1
XFILLER_0_23_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_627_ _195_ _196_ VGND VGND VPWR VPWR _197_ sky130_fd_sc_hd__nor2_2
X_558_ net12 net13 net6 VGND VGND VPWR VPWR _130_ sky130_fd_sc_hd__and3_1
X_489_ _060_ _061_ _053_ VGND VGND VPWR VPWR _063_ sky130_fd_sc_hd__a21o_1
XFILLER_0_1_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_412_ _329_ _337_ _336_ VGND VGND VPWR VPWR _345_ sky130_fd_sc_hd__a21o_1
XFILLER_0_11_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_64 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_76 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_31 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_591_ _158_ _161_ VGND VGND VPWR VPWR _162_ sky130_fd_sc_hd__xor2_1
X_660_ _094_ _010_ _042_ _348_ VGND VGND VPWR VPWR _229_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_21_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput23 net23 VGND VGND VPWR VPWR P[15] sky130_fd_sc_hd__clkbuf_4
X_712_ _276_ _252_ _282_ VGND VGND VPWR VPWR _283_ sky130_fd_sc_hd__o21a_1
X_643_ _211_ _212_ VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__xnor2_2
X_574_ _143_ _144_ _128_ VGND VGND VPWR VPWR _146_ sky130_fd_sc_hd__a21oi_1
XTAP_115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_218 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_626_ _311_ _326_ _134_ VGND VGND VPWR VPWR _196_ sky130_fd_sc_hd__o21ai_1
X_557_ _331_ net14 VGND VGND VPWR VPWR _129_ sky130_fd_sc_hd__nand2_1
X_488_ _053_ _060_ net38 VGND VGND VPWR VPWR _062_ sky130_fd_sc_hd__nand3_1
XFILLER_0_1_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_411_ _344_ VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__clkbuf_1
X_609_ _178_ _155_ VGND VGND VPWR VPWR _180_ sky130_fd_sc_hd__or2b_1
XFILLER_0_24_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_88 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_102 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_168 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_213 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_590_ _159_ _160_ VGND VGND VPWR VPWR _161_ sky130_fd_sc_hd__nor2_1
XFILLER_0_21_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput24 net24 VGND VGND VPWR VPWR P[1] sky130_fd_sc_hd__clkbuf_4
X_642_ _180_ _184_ _179_ VGND VGND VPWR VPWR _212_ sky130_fd_sc_hd__a21bo_1
X_711_ _228_ _253_ VGND VGND VPWR VPWR _282_ sky130_fd_sc_hd__nand2_1
X_573_ _128_ _143_ _144_ VGND VGND VPWR VPWR _145_ sky130_fd_sc_hd__and3_1
XTAP_116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_64 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_625_ _311_ net13 _134_ VGND VGND VPWR VPWR _195_ sky130_fd_sc_hd__and3_1
X_556_ _083_ _127_ VGND VGND VPWR VPWR _128_ sky130_fd_sc_hd__xor2_1
X_487_ _057_ _058_ _059_ VGND VGND VPWR VPWR _061_ sky130_fd_sc_hd__a21o_1
XFILLER_0_22_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_410_ _342_ _343_ VGND VGND VPWR VPWR _344_ sky130_fd_sc_hd__and2_1
X_608_ _155_ _178_ VGND VGND VPWR VPWR _179_ sky130_fd_sc_hd__or2b_1
X_539_ _109_ net39 _078_ VGND VGND VPWR VPWR _112_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_10_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_136 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput25 net25 VGND VGND VPWR VPWR P[2] sky130_fd_sc_hd__buf_2
X_641_ _209_ _210_ VGND VGND VPWR VPWR _211_ sky130_fd_sc_hd__or2b_1
X_710_ _279_ _280_ VGND VGND VPWR VPWR _281_ sky130_fd_sc_hd__nand2_1
X_572_ _140_ _141_ _142_ VGND VGND VPWR VPWR _144_ sky130_fd_sc_hd__o21bai_2
XTAP_117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_111 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_624_ _159_ _193_ VGND VGND VPWR VPWR _194_ sky130_fd_sc_hd__xnor2_1
X_555_ _123_ _126_ VGND VGND VPWR VPWR _127_ sky130_fd_sc_hd__xor2_1
XFILLER_0_13_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_486_ _057_ _058_ _059_ VGND VGND VPWR VPWR _060_ sky130_fd_sc_hd__nand3_1
XFILLER_0_1_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_607_ _157_ _177_ VGND VGND VPWR VPWR _178_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_24_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_538_ _078_ _109_ _110_ VGND VGND VPWR VPWR _111_ sky130_fd_sc_hd__or3_4
XFILLER_0_6_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_469_ _303_ net14 _010_ _275_ VGND VGND VPWR VPWR _043_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_4_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_142 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput26 net26 VGND VGND VPWR VPWR P[3] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_11_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_640_ _185_ _186_ _208_ VGND VGND VPWR VPWR _210_ sky130_fd_sc_hd__a21o_1
X_571_ _140_ _141_ _142_ VGND VGND VPWR VPWR _143_ sky130_fd_sc_hd__or3b_4
XTAP_118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_123 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_623_ _189_ _192_ VGND VGND VPWR VPWR _193_ sky130_fd_sc_hd__xnor2_1
X_554_ _124_ _125_ VGND VGND VPWR VPWR _126_ sky130_fd_sc_hd__nor2_1
X_485_ _019_ _020_ _021_ VGND VGND VPWR VPWR _059_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_13_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_88 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_606_ _175_ _176_ VGND VGND VPWR VPWR _177_ sky130_fd_sc_hd__xnor2_1
X_468_ net16 VGND VGND VPWR VPWR _042_ sky130_fd_sc_hd__inv_2
X_537_ _107_ _108_ _065_ _079_ VGND VGND VPWR VPWR _110_ sky130_fd_sc_hd__o211a_1
X_399_ _234_ _286_ _314_ _331_ VGND VGND VPWR VPWR _333_ sky130_fd_sc_hd__nand4_2
XFILLER_0_10_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_68 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput27 net27 VGND VGND VPWR VPWR P[4] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_11_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_570_ _093_ _101_ _100_ VGND VGND VPWR VPWR _142_ sky130_fd_sc_hd__a21bo_1
XTAP_119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_699_ _269_ _243_ VGND VGND VPWR VPWR _270_ sky130_fd_sc_hd__or2_1
XFILLER_0_4_157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_622_ _190_ _191_ VGND VGND VPWR VPWR _192_ sky130_fd_sc_hd__or2_1
XFILLER_0_13_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_553_ _314_ net15 _042_ _303_ VGND VGND VPWR VPWR _125_ sky130_fd_sc_hd__o2bb2a_1
X_484_ _055_ net37 _054_ VGND VGND VPWR VPWR _058_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_13_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_605_ _128_ _144_ _143_ VGND VGND VPWR VPWR _176_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_39_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_536_ _065_ _079_ net43 _108_ VGND VGND VPWR VPWR _109_ sky130_fd_sc_hd__a211oi_2
X_467_ _014_ _015_ _016_ VGND VGND VPWR VPWR _041_ sky130_fd_sc_hd__o21ba_1
X_398_ _286_ net4 _331_ _234_ VGND VGND VPWR VPWR _332_ sky130_fd_sc_hd__a22o_1
XFILLER_0_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_519_ _326_ _090_ _091_ VGND VGND VPWR VPWR _092_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_27_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_58 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput28 net28 VGND VGND VPWR VPWR P[5] sky130_fd_sc_hd__buf_2
XFILLER_0_7_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput17 net17 VGND VGND VPWR VPWR P[0] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_26_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_698_ _239_ _241_ VGND VGND VPWR VPWR _269_ sky130_fd_sc_hd__and2b_1
XPHY_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_621_ _348_ _010_ _042_ _331_ VGND VGND VPWR VPWR _191_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_13_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_552_ _303_ _314_ net15 net16 VGND VGND VPWR VPWR _124_ sky130_fd_sc_hd__and4b_1
X_483_ _054_ _055_ _056_ VGND VGND VPWR VPWR _057_ sky130_fd_sc_hd__or3_4
XFILLER_0_22_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_604_ _163_ _174_ VGND VGND VPWR VPWR _175_ sky130_fd_sc_hd__xnor2_1
X_535_ _105_ _106_ _088_ VGND VGND VPWR VPWR _108_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_39_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_397_ net5 VGND VGND VPWR VPWR _331_ sky130_fd_sc_hd__clkbuf_4
X_466_ _039_ _040_ VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__xnor2_2
XFILLER_0_4_47 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_518_ net5 net13 net6 net12 VGND VGND VPWR VPWR _091_ sky130_fd_sc_hd__a22o_1
XFILLER_0_35_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_449_ _347_ _349_ _350_ VGND VGND VPWR VPWR _024_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_18_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput29 net29 VGND VGND VPWR VPWR P[6] sky130_fd_sc_hd__clkbuf_4
Xoutput18 net18 VGND VGND VPWR VPWR P[10] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_2_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_697_ _266_ _267_ VGND VGND VPWR VPWR _268_ sky130_fd_sc_hd__nand2_1
XPHY_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_620_ _331_ _348_ _010_ net16 VGND VGND VPWR VPWR _190_ sky130_fd_sc_hd__and4b_1
X_551_ _314_ _000_ _091_ _090_ _326_ VGND VGND VPWR VPWR _123_ sky130_fd_sc_hd__a32o_1
XFILLER_0_13_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_482_ net9 net8 net16 VGND VGND VPWR VPWR _056_ sky130_fd_sc_hd__and3_1
XFILLER_0_1_118 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_603_ _171_ _173_ VGND VGND VPWR VPWR _174_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_24_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_534_ _088_ _105_ _106_ VGND VGND VPWR VPWR _107_ sky130_fd_sc_hd__and3_1
X_465_ _342_ _008_ VGND VGND VPWR VPWR _040_ sky130_fd_sc_hd__nor2_1
X_396_ _303_ _306_ VGND VGND VPWR VPWR _330_ sky130_fd_sc_hd__and2_1
XFILLER_0_4_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_59 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_168 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_38 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_517_ net12 net5 net6 VGND VGND VPWR VPWR _090_ sky130_fd_sc_hd__and3_1
X_448_ _020_ _021_ _019_ VGND VGND VPWR VPWR _023_ sky130_fd_sc_hd__a21o_1
X_379_ net4 VGND VGND VPWR VPWR _314_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_25_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput19 net19 VGND VGND VPWR VPWR P[11] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_27_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_696_ _235_ _237_ _265_ VGND VGND VPWR VPWR _267_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_25_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_481_ net9 net8 net45 VGND VGND VPWR VPWR _055_ sky130_fd_sc_hd__a21oi_1
X_550_ _088_ _105_ _106_ VGND VGND VPWR VPWR _122_ sky130_fd_sc_hd__nand3_1
XFILLER_0_38_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_679_ _010_ _134_ VGND VGND VPWR VPWR _249_ sky130_fd_sc_hd__nand2_1
XFILLER_0_13_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_602_ _133_ net35 _172_ VGND VGND VPWR VPWR _173_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_39_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_533_ _102_ _103_ _104_ VGND VGND VPWR VPWR _106_ sky130_fd_sc_hd__a21o_1
X_464_ _037_ _038_ VGND VGND VPWR VPWR _039_ sky130_fd_sc_hd__or2b_1
X_395_ _327_ _328_ VGND VGND VPWR VPWR _329_ sky130_fd_sc_hd__nor2_1
XFILLER_0_5_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_516_ _314_ net14 VGND VGND VPWR VPWR _089_ sky130_fd_sc_hd__nand2_1
X_378_ net9 net10 net3 net4 VGND VGND VPWR VPWR _313_ sky130_fd_sc_hd__and4_1
XFILLER_0_27_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_447_ _019_ _020_ _021_ VGND VGND VPWR VPWR _022_ sky130_fd_sc_hd__nand3_1
XFILLER_0_25_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_695_ _235_ _237_ _265_ VGND VGND VPWR VPWR _266_ sky130_fd_sc_hd__or3_2
XFILLER_0_4_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_480_ net10 net7 VGND VGND VPWR VPWR _054_ sky130_fd_sc_hd__nand2_2
XFILLER_0_38_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_678_ _000_ _134_ _197_ _195_ VGND VGND VPWR VPWR _248_ sky130_fd_sc_hd__a31o_2
XFILLER_0_0_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_601_ _306_ _135_ VGND VGND VPWR VPWR _172_ sky130_fd_sc_hd__and2_1
XFILLER_0_39_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_532_ _102_ _103_ _104_ VGND VGND VPWR VPWR _105_ sky130_fd_sc_hd__nand3_4
XFILLER_0_24_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_394_ net1 _275_ _311_ _326_ VGND VGND VPWR VPWR _328_ sky130_fd_sc_hd__and4_2
X_463_ _340_ _008_ _035_ _036_ VGND VGND VPWR VPWR _038_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_30_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_515_ _080_ _087_ VGND VGND VPWR VPWR _088_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_35_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_446_ net9 net10 net7 _348_ VGND VGND VPWR VPWR _021_ sky130_fd_sc_hd__nand4_1
X_377_ _245_ _311_ VGND VGND VPWR VPWR _312_ sky130_fd_sc_hd__nand2_1
XFILLER_0_35_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_429_ _353_ _354_ _002_ VGND VGND VPWR VPWR _004_ sky130_fd_sc_hd__a21o_1
Xinput1 A[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__clkbuf_2
XTAP_90 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_694_ _262_ _264_ VGND VGND VPWR VPWR _265_ sky130_fd_sc_hd__xnor2_1
XPHY_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_677_ _246_ VGND VGND VPWR VPWR _247_ sky130_fd_sc_hd__inv_2
XFILLER_0_0_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_600_ _168_ _170_ VGND VGND VPWR VPWR _171_ sky130_fd_sc_hd__xnor2_1
X_531_ _053_ _061_ _060_ VGND VGND VPWR VPWR _104_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_39_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_393_ _275_ _311_ _326_ _245_ VGND VGND VPWR VPWR _327_ sky130_fd_sc_hd__a22oi_1
X_462_ _340_ _008_ _035_ _036_ VGND VGND VPWR VPWR _037_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_4_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_729_ _287_ _289_ _294_ _300_ VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__o211a_1
XFILLER_0_14_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_514_ _085_ _086_ VGND VGND VPWR VPWR _087_ sky130_fd_sc_hd__and2_4
X_376_ net12 VGND VGND VPWR VPWR _311_ sky130_fd_sc_hd__clkbuf_4
X_445_ net9 net7 _348_ net10 VGND VGND VPWR VPWR _020_ sky130_fd_sc_hd__a22o_1
XFILLER_0_35_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_108 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_19 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_428_ _353_ _354_ _002_ VGND VGND VPWR VPWR _003_ sky130_fd_sc_hd__nand3_1
XFILLER_0_11_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_359_ net1 VGND VGND VPWR VPWR _245_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_23_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput2 A[1] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__clkbuf_2
XTAP_80 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_91 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_52 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_222 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_200 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_171 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_693_ _190_ _231_ _263_ VGND VGND VPWR VPWR _264_ sky130_fd_sc_hd__a21bo_1
XPHY_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_676_ _169_ _136_ _223_ VGND VGND VPWR VPWR _246_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_530_ _100_ _101_ _093_ VGND VGND VPWR VPWR _103_ sky130_fd_sc_hd__a21o_1
X_461_ _005_ _034_ _032_ _033_ VGND VGND VPWR VPWR _036_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_39_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_392_ net13 VGND VGND VPWR VPWR _326_ sky130_fd_sc_hd__buf_6
XFILLER_0_10_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_728_ _279_ _284_ _297_ _298_ _299_ VGND VGND VPWR VPWR _300_ sky130_fd_sc_hd__a32o_1
X_659_ _227_ VGND VGND VPWR VPWR _228_ sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_14_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_513_ _083_ _084_ _081_ VGND VGND VPWR VPWR _086_ sky130_fd_sc_hd__o21ai_1
X_444_ net11 net5 VGND VGND VPWR VPWR _019_ sky130_fd_sc_hd__and2_1
X_375_ _307_ _308_ _302_ VGND VGND VPWR VPWR _310_ sky130_fd_sc_hd__nor3b_1
XFILLER_0_33_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_84 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_358_ net9 VGND VGND VPWR VPWR _234_ sky130_fd_sc_hd__buf_2
X_427_ _357_ _001_ VGND VGND VPWR VPWR _002_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_11_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput3 A[2] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__clkbuf_2
XTAP_81 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_92 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_64 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_692_ _226_ _228_ _229_ VGND VGND VPWR VPWR _263_ sky130_fd_sc_hd__or3_1
XFILLER_0_7_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_215 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_218 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_675_ _243_ _244_ VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__nor2_1
XFILLER_0_13_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_52 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_460_ _032_ _033_ _005_ _034_ VGND VGND VPWR VPWR _035_ sky130_fd_sc_hd__a211o_1
X_391_ _312_ _320_ VGND VGND VPWR VPWR _325_ sky130_fd_sc_hd__or2b_1
X_727_ _248_ _272_ _273_ VGND VGND VPWR VPWR _299_ sky130_fd_sc_hd__a21o_1
X_589_ _331_ _010_ _042_ _314_ VGND VGND VPWR VPWR _160_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_14_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_658_ _348_ _010_ net16 _094_ VGND VGND VPWR VPWR _227_ sky130_fd_sc_hd__and4b_1
XFILLER_0_30_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_512_ _081_ _083_ _084_ VGND VGND VPWR VPWR _085_ sky130_fd_sc_hd__or3_4
X_443_ _014_ _017_ VGND VGND VPWR VPWR _018_ sky130_fd_sc_hd__xnor2_1
X_374_ _302_ _309_ VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__xnor2_1
XFILLER_0_35_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_96 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_140 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_426_ net1 _000_ VGND VGND VPWR VPWR _001_ sky130_fd_sc_hd__nand2_1
XFILLER_0_23_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput4 A[3] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_36_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_93 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_82 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_409_ _340_ _341_ _322_ VGND VGND VPWR VPWR _343_ sky130_fd_sc_hd__a21o_1
XFILLER_0_11_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_691_ _258_ _261_ VGND VGND VPWR VPWR _262_ sky130_fd_sc_hd__xnor2_1
Xmax_cap33 _045_ VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_33_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_674_ _242_ _214_ _215_ VGND VGND VPWR VPWR _244_ sky130_fd_sc_hd__and3_1
XFILLER_0_13_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_64 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_202 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_390_ _318_ _319_ VGND VGND VPWR VPWR _324_ sky130_fd_sc_hd__nand2_1
X_726_ _279_ _284_ _297_ VGND VGND VPWR VPWR _298_ sky130_fd_sc_hd__a21o_1
X_657_ _196_ _198_ _195_ VGND VGND VPWR VPWR _226_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_5_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_588_ _314_ _331_ _010_ net16 VGND VGND VPWR VPWR _159_ sky130_fd_sc_hd__and4b_1
XFILLER_0_14_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_171 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_511_ net3 net15 _042_ net2 VGND VGND VPWR VPWR _084_ sky130_fd_sc_hd__o2bb2a_1
X_442_ _015_ _016_ VGND VGND VPWR VPWR _017_ sky130_fd_sc_hd__nor2_1
X_373_ _307_ _308_ VGND VGND VPWR VPWR _309_ sky130_fd_sc_hd__or2_1
XFILLER_0_2_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_709_ _271_ _256_ _278_ VGND VGND VPWR VPWR _280_ sky130_fd_sc_hd__or3_1
XFILLER_0_25_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_163 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_152 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_425_ net14 VGND VGND VPWR VPWR _000_ sky130_fd_sc_hd__buf_2
XFILLER_0_23_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput5 A[4] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__buf_2
XFILLER_0_39_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_94 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_83 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_408_ _322_ _340_ _341_ VGND VGND VPWR VPWR _342_ sky130_fd_sc_hd__nand3_1
XFILLER_0_11_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_690_ _259_ _232_ _260_ VGND VGND VPWR VPWR _261_ sky130_fd_sc_hd__o21a_1
XFILLER_0_17_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_88 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_673_ _214_ _215_ _242_ VGND VGND VPWR VPWR _243_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_0_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_214 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_725_ _295_ _277_ _271_ VGND VGND VPWR VPWR _297_ sky130_fd_sc_hd__a21o_1
X_656_ _221_ _224_ VGND VGND VPWR VPWR _225_ sky130_fd_sc_hd__xor2_1
XFILLER_0_14_12 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_587_ _331_ _000_ _131_ _130_ _094_ VGND VGND VPWR VPWR _158_ sky130_fd_sc_hd__a32o_1
XFILLER_0_5_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_510_ _082_ VGND VGND VPWR VPWR _083_ sky130_fd_sc_hd__buf_1
X_441_ net3 net4 _311_ net13 VGND VGND VPWR VPWR _016_ sky130_fd_sc_hd__and4_1
X_372_ _245_ _306_ _304_ _305_ VGND VGND VPWR VPWR _308_ sky130_fd_sc_hd__o2bb2a_1
X_639_ _185_ _186_ _208_ VGND VGND VPWR VPWR _209_ sky130_fd_sc_hd__and3_1
X_708_ _271_ _256_ _278_ VGND VGND VPWR VPWR _279_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_26_175 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_424_ _355_ _356_ VGND VGND VPWR VPWR _357_ sky130_fd_sc_hd__nor2_1
XFILLER_0_11_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_79 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput6 A[5] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_36_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_95 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_84 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_407_ _324_ _325_ _339_ VGND VGND VPWR VPWR _341_ sky130_fd_sc_hd__nand3_1
XFILLER_0_6_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_170 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_672_ _239_ _241_ VGND VGND VPWR VPWR _242_ sky130_fd_sc_hd__xor2_1
XFILLER_0_0_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_724_ _169_ _223_ VGND VGND VPWR VPWR _295_ sky130_fd_sc_hd__or2_1
X_655_ _170_ _223_ VGND VGND VPWR VPWR _224_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_14_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_586_ _083_ _127_ _156_ VGND VGND VPWR VPWR _157_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_38_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_440_ _314_ _311_ _326_ _303_ VGND VGND VPWR VPWR _015_ sky130_fd_sc_hd__a22oi_2
X_371_ _304_ _305_ net1 _306_ VGND VGND VPWR VPWR _307_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_35_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_707_ _246_ _277_ VGND VGND VPWR VPWR _278_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_25_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_34 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_638_ _188_ _207_ VGND VGND VPWR VPWR _208_ sky130_fd_sc_hd__xnor2_1
X_569_ _136_ net34 _133_ VGND VGND VPWR VPWR _141_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_26_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_423_ net2 net3 _311_ _326_ VGND VGND VPWR VPWR _356_ sky130_fd_sc_hd__and4_1
XFILLER_0_23_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_85 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput7 A[6] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__clkbuf_2
XTAP_96 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_406_ _324_ _325_ _339_ VGND VGND VPWR VPWR _340_ sky130_fd_sc_hd__a21o_1
XFILLER_0_11_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_182 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput10 B[1] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__buf_4
XFILLER_0_3_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_671_ _188_ _207_ _240_ VGND VGND VPWR VPWR _241_ sky130_fd_sc_hd__a21o_1
XFILLER_0_0_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_119 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_654_ _197_ _222_ VGND VGND VPWR VPWR _223_ sky130_fd_sc_hd__xnor2_2
X_723_ _269_ _243_ _291_ _293_ _266_ VGND VGND VPWR VPWR _294_ sky130_fd_sc_hd__o311ai_4
X_585_ _123_ _126_ VGND VGND VPWR VPWR _156_ sky130_fd_sc_hd__and2_1
XTAP_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_370_ net11 VGND VGND VPWR VPWR _306_ sky130_fd_sc_hd__buf_2
XFILLER_0_35_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_637_ _203_ _206_ VGND VGND VPWR VPWR _207_ sky130_fd_sc_hd__xor2_1
X_706_ _273_ _274_ _250_ _276_ VGND VGND VPWR VPWR _277_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_25_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_568_ _133_ _136_ _139_ VGND VGND VPWR VPWR _140_ sky130_fd_sc_hd__and3_1
XFILLER_0_26_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_499_ _071_ _072_ _036_ VGND VGND VPWR VPWR _073_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_1_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_422_ _303_ _311_ _326_ _275_ VGND VGND VPWR VPWR _355_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_23_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput8 A[7] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__buf_6
XTAP_97 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_86 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_405_ _329_ _338_ VGND VGND VPWR VPWR _339_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_11_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_111 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput11 B[2] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__buf_2
XFILLER_0_24_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_670_ _203_ _206_ VGND VGND VPWR VPWR _240_ sky130_fd_sc_hd__and2_1
XFILLER_0_28_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_722_ _290_ VGND VGND VPWR VPWR _293_ sky130_fd_sc_hd__inv_2
X_653_ _000_ _134_ VGND VGND VPWR VPWR _222_ sky130_fd_sc_hd__nand2_1
X_584_ _121_ _148_ _147_ VGND VGND VPWR VPWR _155_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_38_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_636_ _163_ _204_ _205_ VGND VGND VPWR VPWR _206_ sky130_fd_sc_hd__o21ai_1
X_705_ _248_ VGND VGND VPWR VPWR _276_ sky130_fd_sc_hd__inv_2
X_567_ _137_ _138_ _095_ _097_ VGND VGND VPWR VPWR _139_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_25_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_498_ _069_ _070_ _011_ VGND VGND VPWR VPWR _072_ sky130_fd_sc_hd__a21o_1
XFILLER_0_5_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_421_ _351_ _352_ _346_ VGND VGND VPWR VPWR _354_ sky130_fd_sc_hd__a21o_1
XFILLER_0_23_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput9 B[0] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__buf_6
XTAP_98 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_87 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_619_ _348_ _000_ _165_ _164_ VGND VGND VPWR VPWR _189_ sky130_fd_sc_hd__a31o_1
XFILLER_0_14_115 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_404_ _336_ _337_ VGND VGND VPWR VPWR _338_ sky130_fd_sc_hd__and2b_1
XFILLER_0_6_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_36 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput12 B[3] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__buf_4
XFILLER_0_30_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_202 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_652_ _170_ _199_ _136_ VGND VGND VPWR VPWR _221_ sky130_fd_sc_hd__o21ai_1
X_721_ _290_ _292_ VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__xnor2_2
X_583_ _153_ _154_ VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__xnor2_1
XFILLER_0_30_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_704_ _248_ _272_ VGND VGND VPWR VPWR _274_ sky130_fd_sc_hd__nand2_1
X_635_ _173_ _171_ VGND VGND VPWR VPWR _205_ sky130_fd_sc_hd__or2b_1
X_566_ net11 _095_ _096_ VGND VGND VPWR VPWR _138_ sky130_fd_sc_hd__and3_1
X_497_ _011_ _069_ _070_ VGND VGND VPWR VPWR _071_ sky130_fd_sc_hd__nand3_1
XFILLER_0_5_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_420_ _346_ _351_ _352_ VGND VGND VPWR VPWR _353_ sky130_fd_sc_hd__nand3_1
XFILLER_0_23_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_99 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_88 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_618_ _124_ _162_ _187_ VGND VGND VPWR VPWR _188_ sky130_fd_sc_hd__a21o_1
X_549_ _085_ _120_ VGND VGND VPWR VPWR _121_ sky130_fd_sc_hd__and2_1
XFILLER_0_14_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_132 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_403_ _334_ _335_ _313_ _316_ VGND VGND VPWR VPWR _337_ sky130_fd_sc_hd__a211o_1
XPHY_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput13 B[4] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__buf_2
XFILLER_0_33_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_720_ _269_ _243_ _291_ _266_ VGND VGND VPWR VPWR _292_ sky130_fd_sc_hd__o31a_1
X_651_ _194_ _202_ VGND VGND VPWR VPWR _220_ sky130_fd_sc_hd__or2_1
X_582_ _115_ _118_ _114_ VGND VGND VPWR VPWR _154_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_38_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_634_ _171_ _173_ VGND VGND VPWR VPWR _204_ sky130_fd_sc_hd__and2b_1
X_703_ _248_ _272_ _250_ VGND VGND VPWR VPWR _273_ sky130_fd_sc_hd__o21a_1
X_565_ _306_ _134_ _095_ _096_ VGND VGND VPWR VPWR _137_ sky130_fd_sc_hd__a22oi_2
X_496_ _067_ _068_ _030_ _032_ VGND VGND VPWR VPWR _070_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_1_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_617_ _158_ _161_ VGND VGND VPWR VPWR _187_ sky130_fd_sc_hd__and2_1
XFILLER_0_36_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_89 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_548_ _080_ _087_ VGND VGND VPWR VPWR _120_ sky130_fd_sc_hd__or2b_1
X_479_ _049_ _052_ VGND VGND VPWR VPWR _053_ sky130_fd_sc_hd__xor2_1
XFILLER_0_14_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_144 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_402_ _313_ _316_ _334_ _335_ VGND VGND VPWR VPWR _336_ sky130_fd_sc_hd__o211a_1
XPHY_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput14 B[5] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_23_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_650_ _200_ _201_ VGND VGND VPWR VPWR _219_ sky130_fd_sc_hd__nand2_1
XFILLER_0_14_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_581_ _151_ _152_ VGND VGND VPWR VPWR _153_ sky130_fd_sc_hd__or2_1
XFILLER_0_38_145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_633_ _194_ _202_ VGND VGND VPWR VPWR _203_ sky130_fd_sc_hd__xor2_1
X_702_ _134_ _042_ _249_ VGND VGND VPWR VPWR _272_ sky130_fd_sc_hd__o21ai_1
X_564_ _306_ _135_ VGND VGND VPWR VPWR _136_ sky130_fd_sc_hd__nand2_2
X_495_ _030_ _032_ _067_ _068_ VGND VGND VPWR VPWR _069_ sky130_fd_sc_hd__a211o_1
XFILLER_0_5_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_616_ _157_ _177_ VGND VGND VPWR VPWR _186_ sky130_fd_sc_hd__or2b_1
X_547_ _078_ _109_ net39 VGND VGND VPWR VPWR _119_ sky130_fd_sc_hd__nor3_1
X_478_ _331_ _050_ net42 VGND VGND VPWR VPWR _052_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_22_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_401_ _332_ _333_ _330_ VGND VGND VPWR VPWR _335_ sky130_fd_sc_hd__a21o_1
XPHY_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_118 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput15 B[6] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_23_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_580_ _149_ _150_ net41 _119_ VGND VGND VPWR VPWR _152_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_38_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_701_ _172_ _223_ VGND VGND VPWR VPWR _271_ sky130_fd_sc_hd__and2_1
X_632_ _200_ _201_ VGND VGND VPWR VPWR _202_ sky130_fd_sc_hd__xnor2_1
X_563_ _234_ _286_ _134_ VGND VGND VPWR VPWR _135_ sky130_fd_sc_hd__and3_1
X_494_ _065_ _066_ _048_ VGND VGND VPWR VPWR _068_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_34_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_116 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_160 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_615_ _176_ _175_ VGND VGND VPWR VPWR _185_ sky130_fd_sc_hd__or2b_1
X_546_ _116_ _118_ VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__xnor2_1
X_477_ net12 net5 net6 net11 VGND VGND VPWR VPWR _051_ sky130_fd_sc_hd__a22o_1
XFILLER_0_22_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_400_ _330_ _332_ _333_ VGND VGND VPWR VPWR _334_ sky130_fd_sc_hd__nand3_1
XFILLER_0_36_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_529_ _093_ _100_ _101_ VGND VGND VPWR VPWR _102_ sky130_fd_sc_hd__nand3_1
XFILLER_0_27_200 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_222 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput16 B[7] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__buf_8
XFILLER_0_15_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_700_ _268_ _270_ VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__xnor2_1
X_631_ _168_ _169_ _172_ VGND VGND VPWR VPWR _201_ sky130_fd_sc_hd__a21o_1
X_562_ net8 VGND VGND VPWR VPWR _134_ sky130_fd_sc_hd__buf_2
X_493_ _048_ _065_ _066_ VGND VGND VPWR VPWR _067_ sky130_fd_sc_hd__and3_1
XFILLER_0_1_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_172 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_614_ _181_ _184_ VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__xnor2_1
X_476_ net11 net12 net6 VGND VGND VPWR VPWR _050_ sky130_fd_sc_hd__and3_1
X_545_ _073_ _075_ _117_ VGND VGND VPWR VPWR _118_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_22_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_528_ _097_ _098_ _099_ VGND VGND VPWR VPWR _101_ sky130_fd_sc_hd__a21o_1
XFILLER_0_27_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_459_ _005_ _006_ _328_ VGND VGND VPWR VPWR _034_ sky130_fd_sc_hd__and3b_1
XFILLER_0_5_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_115 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_63 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_630_ _170_ _199_ VGND VGND VPWR VPWR _200_ sky130_fd_sc_hd__xor2_1
X_561_ _129_ _132_ VGND VGND VPWR VPWR _133_ sky130_fd_sc_hd__xor2_2
X_492_ _062_ _063_ _064_ VGND VGND VPWR VPWR _066_ sky130_fd_sc_hd__a21o_1
XFILLER_0_34_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_195 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_613_ _118_ _182_ _183_ VGND VGND VPWR VPWR _184_ sky130_fd_sc_hd__o21ai_1
X_475_ _314_ _326_ VGND VGND VPWR VPWR _049_ sky130_fd_sc_hd__nand2_1
X_544_ _036_ _071_ _072_ VGND VGND VPWR VPWR _117_ sky130_fd_sc_hd__and3b_1
XFILLER_0_22_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_527_ _097_ _098_ _099_ VGND VGND VPWR VPWR _100_ sky130_fd_sc_hd__nand3_2
X_389_ _322_ _323_ VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__nor2_1
XFILLER_0_12_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_458_ _030_ _031_ _013_ VGND VGND VPWR VPWR _033_ sky130_fd_sc_hd__a21o_1
XFILLER_0_12_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_63 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_30 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_560_ _094_ _130_ _131_ VGND VGND VPWR VPWR _132_ sky130_fd_sc_hd__a21bo_1
X_491_ _062_ _063_ _064_ VGND VGND VPWR VPWR _065_ sky130_fd_sc_hd__nand3_2
XFILLER_0_19_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_689_ _221_ _224_ VGND VGND VPWR VPWR _260_ sky130_fd_sc_hd__nand2_1
XFILLER_0_15_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_612_ _114_ _151_ _152_ VGND VGND VPWR VPWR _183_ sky130_fd_sc_hd__o21bai_1
X_543_ _114_ _115_ VGND VGND VPWR VPWR _116_ sky130_fd_sc_hd__nor2_1
X_474_ _041_ _047_ VGND VGND VPWR VPWR _048_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_22_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_171 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_526_ _054_ _055_ net36 VGND VGND VPWR VPWR _099_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_27_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_457_ _013_ _030_ _031_ VGND VGND VPWR VPWR _032_ sky130_fd_sc_hd__nand3_2
X_388_ _310_ _321_ VGND VGND VPWR VPWR _323_ sky130_fd_sc_hd__nor2_1
XTAP_180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_509_ net2 net3 net15 net16 VGND VGND VPWR VPWR _082_ sky130_fd_sc_hd__and4b_1
XFILLER_0_23_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_75 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_10 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_490_ _018_ _026_ _025_ VGND VGND VPWR VPWR _064_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_34_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_688_ _225_ VGND VGND VPWR VPWR _259_ sky130_fd_sc_hd__inv_2
XFILLER_0_15_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_611_ _114_ _115_ _151_ _152_ VGND VGND VPWR VPWR _182_ sky130_fd_sc_hd__or4_4
X_542_ net44 _112_ _113_ VGND VGND VPWR VPWR _115_ sky130_fd_sc_hd__a21oi_2
X_473_ net33 _046_ VGND VGND VPWR VPWR _047_ sky130_fd_sc_hd__nor2_1
XFILLER_0_22_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_525_ net11 _094_ _095_ _096_ VGND VGND VPWR VPWR _098_ sky130_fd_sc_hd__a22o_1
X_456_ _027_ _028_ _029_ VGND VGND VPWR VPWR _031_ sky130_fd_sc_hd__a21o_1
XFILLER_0_12_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_387_ _310_ _321_ VGND VGND VPWR VPWR _322_ sky130_fd_sc_hd__and2_1
XFILLER_0_37_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_508_ net4 _326_ _051_ _050_ _331_ VGND VGND VPWR VPWR _081_ sky130_fd_sc_hd__a32oi_2
X_439_ _275_ _000_ VGND VGND VPWR VPWR _014_ sky130_fd_sc_hd__nand2_1
XFILLER_0_2_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_87 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_687_ _256_ _257_ VGND VGND VPWR VPWR _258_ sky130_fd_sc_hd__or2_1
XFILLER_0_31_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_610_ _179_ _180_ VGND VGND VPWR VPWR _181_ sky130_fd_sc_hd__nand2_1
X_541_ _111_ _112_ _113_ VGND VGND VPWR VPWR _114_ sky130_fd_sc_hd__and3_1
X_472_ _245_ _042_ _043_ _044_ VGND VGND VPWR VPWR _046_ sky130_fd_sc_hd__o22a_1
XFILLER_0_13_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_190 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer10 _107_ VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__clkbuf_1
XPHY_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_524_ _306_ _094_ _095_ _096_ VGND VGND VPWR VPWR _097_ sky130_fd_sc_hd__nand4_2
X_455_ _027_ _028_ _029_ VGND VGND VPWR VPWR _030_ sky130_fd_sc_hd__nand3_2
X_386_ _312_ _320_ VGND VGND VPWR VPWR _321_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_37_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_219 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_507_ _044_ _045_ VGND VGND VPWR VPWR _080_ sky130_fd_sc_hd__nor2_1
X_369_ _275_ _286_ _303_ _234_ VGND VGND VPWR VPWR _305_ sky130_fd_sc_hd__a22oi_1
X_438_ _011_ _012_ VGND VGND VPWR VPWR _013_ sky130_fd_sc_hd__nor2_1
Xrebuffer1 _139_ VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_55 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_686_ _247_ _254_ VGND VGND VPWR VPWR _257_ sky130_fd_sc_hd__and2_1
XFILLER_0_15_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_540_ _011_ _070_ _069_ VGND VGND VPWR VPWR _113_ sky130_fd_sc_hd__a21bo_1
X_471_ net1 _042_ _043_ _044_ VGND VGND VPWR VPWR _045_ sky130_fd_sc_hd__nor4_1
XFILLER_0_22_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_669_ _237_ _238_ VGND VGND VPWR VPWR _239_ sky130_fd_sc_hd__or2_1
XFILLER_0_26_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer11 _111_ VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__clkbuf_1
XPHY_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_523_ net9 net10 net8 VGND VGND VPWR VPWR _096_ sky130_fd_sc_hd__o21a_4
X_454_ _354_ _002_ _353_ VGND VGND VPWR VPWR _029_ sky130_fd_sc_hd__a21bo_1
X_385_ _318_ _319_ VGND VGND VPWR VPWR _320_ sky130_fd_sc_hd__xor2_1
XFILLER_0_10_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_506_ _048_ _065_ _066_ VGND VGND VPWR VPWR _079_ sky130_fd_sc_hd__nand3_1
Xrebuffer2 _139_ VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_23_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_368_ _234_ net2 _286_ _303_ VGND VGND VPWR VPWR _304_ sky130_fd_sc_hd__and4_1
X_437_ _245_ _010_ _356_ _009_ VGND VGND VPWR VPWR _012_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_2_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_67 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_685_ _247_ _254_ VGND VGND VPWR VPWR _256_ sky130_fd_sc_hd__nor2_1
XFILLER_0_15_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_470_ net2 _303_ net14 net15 VGND VGND VPWR VPWR _044_ sky130_fd_sc_hd__and4_1
XFILLER_0_22_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_599_ _136_ _169_ VGND VGND VPWR VPWR _170_ sky130_fd_sc_hd__nand2_2
X_668_ _235_ _236_ _218_ VGND VGND VPWR VPWR _238_ sky130_fd_sc_hd__o21a_1
XFILLER_0_13_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer12 net16 VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__clkbuf_1
XPHY_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_522_ net9 net10 net8 VGND VGND VPWR VPWR _095_ sky130_fd_sc_hd__nand3_2
X_453_ _025_ _026_ _018_ VGND VGND VPWR VPWR _028_ sky130_fd_sc_hd__a21o_1
XFILLER_0_12_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_384_ _304_ _307_ VGND VGND VPWR VPWR _319_ sky130_fd_sc_hd__or2_1
XFILLER_0_37_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_505_ _041_ net33 _046_ VGND VGND VPWR VPWR _078_ sky130_fd_sc_hd__or3_1
X_436_ _356_ _009_ _245_ _010_ VGND VGND VPWR VPWR _011_ sky130_fd_sc_hd__o211a_1
XFILLER_0_2_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer3 _056_ VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__clkbuf_1
X_367_ net3 VGND VGND VPWR VPWR _303_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_3_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_47 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_419_ _349_ _350_ _347_ VGND VGND VPWR VPWR _352_ sky130_fd_sc_hd__a21o_1
XFILLER_0_34_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_176 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_684_ _228_ _253_ VGND VGND VPWR VPWR _254_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_25_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_667_ _218_ _235_ _236_ VGND VGND VPWR VPWR _237_ sky130_fd_sc_hd__nor3_1
X_598_ _234_ _286_ _306_ _134_ VGND VGND VPWR VPWR _169_ sky130_fd_sc_hd__o31a_2
XFILLER_0_13_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_182 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_521_ net7 VGND VGND VPWR VPWR _094_ sky130_fd_sc_hd__clkbuf_4
X_452_ _018_ _025_ _026_ VGND VGND VPWR VPWR _027_ sky130_fd_sc_hd__nand3_1
X_383_ _316_ _317_ VGND VGND VPWR VPWR _318_ sky130_fd_sc_hd__nor2_1
XFILLER_0_12_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_719_ _267_ VGND VGND VPWR VPWR _291_ sky130_fd_sc_hd__inv_2
XFILLER_0_37_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_435_ net15 VGND VGND VPWR VPWR _010_ sky130_fd_sc_hd__buf_2
X_366_ _296_ _302_ VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__nor2_1
X_504_ _076_ _077_ VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__nor2_1
Xrebuffer4 _056_ VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_23_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_182 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_59 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_418_ _347_ _349_ _350_ VGND VGND VPWR VPWR _351_ sky130_fd_sc_hd__nand3_1
XFILLER_0_37_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_188 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_683_ _248_ _252_ VGND VGND VPWR VPWR _253_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_15_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_666_ _219_ _220_ _233_ VGND VGND VPWR VPWR _236_ sky130_fd_sc_hd__and3_1
X_597_ _166_ _167_ VGND VGND VPWR VPWR _168_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_6_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_520_ _089_ _092_ VGND VGND VPWR VPWR _093_ sky130_fd_sc_hd__xor2_2
X_451_ _022_ _023_ _024_ VGND VGND VPWR VPWR _026_ sky130_fd_sc_hd__a21o_1
X_382_ _275_ _306_ _313_ _315_ VGND VGND VPWR VPWR _317_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_10_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_649_ _217_ VGND VGND VPWR VPWR _218_ sky130_fd_sc_hd__inv_2
X_718_ _287_ _289_ VGND VGND VPWR VPWR _290_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_5_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_503_ _073_ _074_ _075_ VGND VGND VPWR VPWR _077_ sky130_fd_sc_hd__a21oi_1
X_365_ _234_ _245_ _275_ _286_ VGND VGND VPWR VPWR _302_ sky130_fd_sc_hd__and4_1
X_434_ _245_ _000_ _357_ VGND VGND VPWR VPWR _009_ sky130_fd_sc_hd__and3_1
XFILLER_0_2_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer5 _061_ VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_194 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_417_ net9 _286_ net5 _348_ VGND VGND VPWR VPWR _350_ sky130_fd_sc_hd__nand4_2
XFILLER_0_0_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_112 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_682_ _250_ _251_ VGND VGND VPWR VPWR _252_ sky130_fd_sc_hd__nand2_1
XFILLER_0_25_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_665_ _219_ _220_ _233_ VGND VGND VPWR VPWR _235_ sky130_fd_sc_hd__a21oi_2
X_596_ _348_ _000_ VGND VGND VPWR VPWR _167_ sky130_fd_sc_hd__nand2_1
XFILLER_0_6_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_450_ _022_ _023_ _024_ VGND VGND VPWR VPWR _025_ sky130_fd_sc_hd__nand3_1
X_381_ _313_ _315_ _275_ _306_ VGND VGND VPWR VPWR _316_ sky130_fd_sc_hd__and4bb_1
X_648_ _159_ _193_ _216_ VGND VGND VPWR VPWR _217_ sky130_fd_sc_hd__a21bo_1
X_717_ _258_ _261_ _288_ VGND VGND VPWR VPWR _289_ sky130_fd_sc_hd__o21ba_2
XFILLER_0_5_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_579_ net40 _119_ _149_ _150_ VGND VGND VPWR VPWR _151_ sky130_fd_sc_hd__o211a_1
XFILLER_0_26_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_502_ _073_ _074_ _075_ VGND VGND VPWR VPWR _076_ sky130_fd_sc_hd__and3_1
X_433_ _328_ _007_ VGND VGND VPWR VPWR _008_ sky130_fd_sc_hd__xnor2_2
X_364_ _234_ _275_ _286_ _245_ VGND VGND VPWR VPWR _296_ sky130_fd_sc_hd__a22oi_1
Xrebuffer6 _110_ VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_1_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_416_ net10 net5 _348_ net9 VGND VGND VPWR VPWR _349_ sky130_fd_sc_hd__a22o_1
XFILLER_0_34_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_681_ _094_ _042_ _249_ VGND VGND VPWR VPWR _251_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_25_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_664_ _225_ _232_ VGND VGND VPWR VPWR _233_ sky130_fd_sc_hd__xor2_1
X_595_ _164_ _165_ VGND VGND VPWR VPWR _166_ sky130_fd_sc_hd__and2b_1
XFILLER_0_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_380_ _286_ _303_ _314_ _234_ VGND VGND VPWR VPWR _315_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_35_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput30 net30 VGND VGND VPWR VPWR P[7] sky130_fd_sc_hd__clkbuf_4
X_716_ _262_ _264_ VGND VGND VPWR VPWR _288_ sky130_fd_sc_hd__and2b_1
X_647_ _192_ _189_ VGND VGND VPWR VPWR _216_ sky130_fd_sc_hd__or2b_1
X_578_ _147_ _148_ _121_ VGND VGND VPWR VPWR _150_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_5_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
.ends
